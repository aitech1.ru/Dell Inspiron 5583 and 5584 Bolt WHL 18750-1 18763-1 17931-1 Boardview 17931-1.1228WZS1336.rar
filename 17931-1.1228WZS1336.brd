# Allegro board 17931-1.1228WZS1336.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PQ4405_6: length 5.5
  TOP w0.089: PC4438.2 205.24,42.01 v1(205.24,42.75) 205.46,42.98 PR4450.1 203.93,43.64 v2(203.41,44.17)
  BOTTOM w0.089: PQ4405.6 203.85,44.97 203.41,44.53 v2(203.41,44.17)
PQ4408_C: length 4.4
  TOP w0.089: 207.27,46.2 207.27,45.96 PR4475.1 208.29,44.93 v1(208.66,44.93) 208.71,44.93 209.22,45.44 v2(209.35,45.44)
  BOTTOM w0.089: PQ4408.C 209.64,45.73 v2(209.35,45.44)
PQ4408_E: length 3.4
  TOP w0.089: PR4473.2 209.96,44.22 v2(210.57,44.22) 210.57,44.67 v1(210.72,44.82) 210.82,44.92 PR4436.1
  BOTTOM w0.089: PQ4408.E 210.36,44.22 v2(210.57,44.22)
PQ4417_D: length 5.4
  TOP w0.089: PQ4417.D 11.84,128.32 PR4498.2 13.54,128.32 14.25,129.03 v1(15.09,129.03) 15.47,129.03 15.7,128.8 PR4431.2
PQ4417_G: length 2.9
  TOP w0.089: PR4430.1 12.72,129.31 PQ4417.G 11.81,129.85 v1(11.23,130.43)
PQ4418_2: length 3.4
  TOP w0.089: PR4499.1 13.34,126.75 PR4498.1 12.96,127.46 12.72,127.7 v1(12.42,127.7) 11.76,127.04 PQ4418.2
PQ4418_3: length 5.2
  TOP w0.089: PQ4418.3 11.11,125.95 ; 11.11,125.95 11.31,125.76 12.62,125.76 12.8,125.58 12.8,124.97 13.01,124.77 PR4433.1 ; 11.11,125.95 10.46,125.3 v1(10.01,125.3)
PQ4418_5: length 4.4
  TOP w0.089: PQ4418.5 11.76,124.31 12.07,124 v2(12.07,123.62) v1(11.43,123.62)
  BOTTOM w0.089: PC4449.1 PR4497.2 12.4,123.95 v2(12.07,123.62)
PQ4418_6: length 15.9
  TOP w0.089: PQ4418.6 12.41,124.14 v2(13.51,123.04)
  L5 w0.089: v2(9.27,116.92) 9.27,117.88 11.13,119.74 11.13,122.35 11.81,123.04 v2(13.51,123.04)
  BOTTOM w0.089: v2(9.27,116.92) 9.12,116.77 9.12,114.78 9.76,114.15 PR4432.1 ; PC4449.2 13.52,123.04 v2(13.51,123.04) v1(13.1,122.62)
PRIM_PWRGD: length 3
  TOP w0.089: R4030.1 21.72,59.41 v1(22.46,60.15) 22.46,60.33 23.02,60.89 U2401.30
PROCHOT: length 4.8
  TOP w0.089: Q2408.G 43.52,67.11 v1(42.55,67.11) 41.42,67.11 40.87,67.11 R2417.1 40.69,67.29 U2401.83
PROCHOT#_CPU: length 460.9
  TOP w0.089: v2(14.1,124.59) 14.1,124.5 13.5,123.9 PR4433.2 ; v2(82.02,155.37) 82.02,154.59 83.71,152.9 PR4603.2 ; v2(93.53,147.18) 93.18,147.18 ED2403.2 ; v2(47.06,70.01) 47.04,69.99 47.04,69.98 46.08,69.01 v1(46.08,67.04) 46.08,66.39 Q2408.D
  L3 w0.089: v2(63.76,109.75) 61.51,112 61.51,113 62.21,113.7 62.21,116.02 61.26,116.97 58.47,116.97 55.49,119.96 55.11,119.96 54.28,120.79 54.28,122.2 53.53,122.96 53.53,130.68 54.69,131.85 55.68,131.85 57.41,133.58 57.41,137.23 58.06,137.88 61.07,137.88 62.59,139.4 62.59,139.98 v2(62.49,140.08) 63.29,140.89 65.51,140.89 67.83,143.21 69.88,143.21 70.28,143.61 81.25,143.61 83.02,145.38 83.89,145.38 86.08,147.57 91.39,147.57 91.53,147.43 92.25,147.43 92.5,147.18 v2(93.53,147.18)
  L5 w0.089: v2(203.93,43.11) 205.57,44.75 205.57,47.44 206.1,47.98 208.56,47.98 v2(208.65,47.89) ; v2(76.76,112.29) 75.74,111.27 69.95,111.27 68.43,109.75 v2(63.76,109.75) 63.2,109.2 63.2,108.09 62.96,107.86 62.96,106.2 62.58,105.82 62.58,105.29 60.48,103.19 60.48,98.99 59.85,98.35 59.85,97.65 57.49,95.3 55.79,95.3 54.33,93.84 54.33,93.04 51.5,90.2 51.5,89.15 51.97,88.67 51.97,78.79 51.01,77.83 51.01,74.35 49.89,73.23 49.89,72.34 49.68,72.14 49,72.14 47.06,70.2 v2(47.06,70.01) 47.06,68.18 43.07,64.19 42.02,64.19 40.26,62.43 40.26,61.63 35.44,56.8 35.44,54.99 30.71,50.27 30.71,48.13 31.07,47.78 31.07,46.19 31.96,45.29 31.96,44.45 32.55,43.87 59.46,43.87 59.84,43.49 97.7,43.49 99.08,44.88 102.85,44.88 104.05,43.68 105.36,43.68 105.68,44.01 110.02,44.01 111.12,45.11 127.47,45.11 129.71,42.86 132.28,42.86 132.7,42.44 161.98,42.44 163.7,40.72 166.37,40.72 166.57,40.52 v2(166.57,40.43)
  L6 w0.089: v2(93.53,147.18) 92.5,147.18 92.23,147.45 91.44,147.45 90.2,148.69 86.9,148.69 83.57,152.02 83.57,154.92 83.11,155.37 v2(82.02,155.37) ; v2(203.93,43.11) 203.83,43.21 201.73,43.21 200.87,42.34 198.1,42.34 197.74,41.99 196.46,41.99 195.89,41.41 194.24,41.41 192.75,39.92 192.75,38.01 190.33,35.59 185.89,35.59 183.66,33.36 169.3,33.36 v2(168.88,33.78) ; v2(14.1,124.59) 14.35,124.59 15.29,125.53 19.94,125.53 20.17,125.3 25.43,125.3 26.5,126.37 26.5,128.25 28.52,130.28 28.63,130.38 28.63,132.49 29.54,133.4 35.94,133.4 35.97,133.43 35.97,133.43 36.32,133.78 48.11,133.78 48.51,134.19 50.45,134.19 51.29,133.35 53.5,133.35 56.01,135.87 56.01,137.87 57.38,139.24 60.79,139.24 61.62,140.08 v2(62.49,140.08)
  BOTTOM w0.089: v2(166.57,40.43) 166.63,40.38 166.63,35.71 166.53,35.61 166.53,34.85 167.01,34.37 168.29,34.37 v2(168.88,33.78) ; v2(203.93,43.11) 203.93,42.85 204.32,42.46 PR4476.2 ; v2(76.76,112.29) 76.58,112.47 R302.1 R301.2 ; PQ4416.3 208.17,47.41 v2(208.65,47.89) ; PR4607.1 80.85,154.48 81.31,154.93 81.58,154.93 v2(82.02,155.37)
PROCHOT#_CPU_R: length 14.9
  L6 w0.089: v2(80.64,104.04) 80.64,104.05 80.62,104.07 80.62,106.25 79.07,107.8 78.87,107.8 v2(78.87,107.8)
  BOTTOM w0.089: v2(78.87,107.8) 78.31,107.8 77.44,108.67 76.43,108.67 75.95,109.15 75.95,111.18 76.33,111.56 76.33,112.57 75.7,113.21 v1(75.7,113.46) 76.13,113.89 R302.2 ; CPU1.Y4 80.26,104.43 80.64,104.05 v2(80.64,104.04)
PROJECT_ID0: length 3.1
  TOP w0.089: v1(109.93,92.3) v2(109.93,91.75) 109.93,91.66 109.45,91.17 R2114.1 110.4,91.08 R2113.2
  BOTTOM w0.089: v2(109.93,91.75) 109.93,91.99 CPU1.CH23
PROJECT_ID1: length 3.1
  TOP w0.089: R2111.2 112.98,95.35 R2112.1 112.32,94.69 v1(111.79,94.69) 111.43,94.69 v2(111.2,94.92)
  BOTTOM w0.089: v2(111.2,94.92) 110.96,95.17 CPU1.CK19
PROJECT_ID2: length 4.9
  TOP w0.089: v2(108.59,95.94) 109.1,96.45 v1(109.65,96.45) 111.3,96.45 R2118.1 111.6,96.39 R2117.2
  BOTTOM w0.089: CPU1.CG17 109.01,96.18 108.77,95.94 v2(108.59,95.94)
PROJECT_ID3: length 6.9
  TOP w0.089: v2(115.04,93.73) 114.68,93.37 113.77,93.37 R2115.2 113.59,93.2 R2116.1
  BOTTOM w0.089: CPU1.CN20 112.61,94.26 113.71,94.26 113.93,94.48 115.4,94.48 115.52,94.35 v1(115.52,94.24) 115.52,94.07 115.18,93.73 v2(115.04,93.73)
PS_ID: length 67.3
  TOP w0.203: U2401.36 26.35,59.93
  TOP w0.254: v2(28.28,97.82) 28.27,97.82 26.3,95.68 25.69,95.68 v1(25.41,95.4) 25.02,95.02 25.02,94.54 25,94.51 R4304.2 R4305.2 24.18,94.54 D4302.3 ; 26.35,59.93 26.35,63.69 27.1,64.44 27.1,64.47 27.4,64.77 27.44,64.77 27.77,65.1 28.86,65.1 30.03,66.27 v2(30.03,66.78)
  L3 w0.254: v2(28.28,97.82) 28.28,97.81 28.76,97.33 30.79,97.33 31.6,96.52 31.6,94.11 32.02,93.69 38.64,93.69 39.6,93.69 40.9,92.39 40.9,76.92 39.46,75.48 39.46,74.18 38.18,72.9 35.8,72.9 34.97,72.07 34.1,72.07 32.76,72.08 32.03,71.35 32.03,71.24 32.01,71.22 32.01,69.57 31.63,69.19 31.63,68.51 30.03,66.9 v2(30.03,66.78)
PS_ID_R: length 38.2
  TOP w0.254: v2(24.63,97.7) 24.66,97.73 Q4301.D 25.75,97.73 26.14,98.12 R4309.1
  L5 w0.254: v2(20.2,123.62) 20.73,123.09 20.73,121.39 20.12,120.78 18.81,120.78 16.05,118.02 15.91,117.88 14.81,117.88 14.43,117.5 14.43,114.19 14.73,113.89 15.42,113.89 16.87,112.45 16.87,109.37 19.42,106.82 19.42,106.2 20.58,105.04 20.58,101.58 23.05,99.11 23.22,99.11 v2(24.63,97.7)
  BOTTOM w0.254: DCIN1.4 v2(20.2,123.62)
PS_ID_R1: length 3.1
  TOP w0.254: R4305.1 24.26,96.4 23.88,96.78 Q4301.S 22.99,96.47 v1(22.99,95.8)
PSID_DISABLE#_R_C: length 4.8
  TOP w0.254: R4303.2 19.54,99.21 19.54,98.77 19.83,98.48 20.8,98.48 Q4302.C 21.01,98.68 v1(22.15,98.68) Q4301.G
PTP_DIS#: length 154.4
  TOP w0.089: v2(107.83,33.71) 107.83,33.02 107.29,32.49 AFTP6526.1 ; v2(31.45,70.74) 32.22,69.97 33.57,69.97 34.11,70.5 34.11,70.51 34.51,70.92 37.26,70.92 38.09,70.09 U2401.90
  L5 w0.089: v2(102.14,35.49) 101.86,35.76 93.77,35.76 93.14,35.12 54.32,35.12 52.49,33.29 35.41,33.29 30.63,28.51 29.7,28.51 29.41,28.51 29.35,28.45 22.35,28.45 18.08,32.72 18.08,35.95 17.6,36.43 17.6,49.76 18.01,50.17 18.01,55.75 20.55,58.29 20.59,58.29 20.84,58.54 20.84,58.58 23.52,61.26 23.52,62.09 27.74,66.31 27.74,67.38 30.1,69.74 30.1,70.12 30.72,70.74 v2(31.45,70.74)
  BOTTOM w0.089: v2(102.14,35.49) 102.14,33.88 103.55,32.47 107.44,32.47 107.83,32.85 v2(107.83,33.71) 108.2,34.08 TP1.3
PU4348_G: length 11.3
  TOP w0.305: v2(31.63,126.8) Q4448.G 32.35,127.59 R4469.2 32.93,127.23 R4468.2 ; R4467.1 29.57,122.33 v2(29.8,122.56)
  L6 w0.254: v2(31.63,126.8) 30.84,126.8 30.28,126.23 30.28,123.04 30.28,123.04 30.28,122.94 29.9,122.56 v2(29.8,122.56)
  BOTTOM w0.305: v1(27.92,121.08) 28.32,121.08 v2(29.8,122.56)
PULSAR_38P4M_REFCLK: length 93.1
  TOP w0.114: v1(113.49,119.53) 112.96,119.53 v2(112.93,119.5)
  L5 w0.114: v2(112.93,119.5) 110.39,122.05 102.62,122.05 101.81,121.24 86.01,121.24 85.91,121.34 66.31,121.34 66.31,121.34 66,121.34 62.24,117.58 56.08,117.58 54.9,116.39 54.9,114.36 53.39,112.85 52.49,112.85 51.86,112.22 51.86,108.41 51.24,107.78 48.65,107.78 47.66,106.79 46.97,106.79 v2(46.54,106.35)
  L6 w0.114: v2(112.93,119.5) 112.93,118.52 118.65,112.8 120.02,112.8 v2(120.55,112.27)
  BOTTOM w0.114: R1804.2 121.54,114.45 arc(121.32,113.35) 120.7,112.42 v2(120.55,112.27) ; WLAN1.64 46.7,106.19 v2(46.54,106.35)
PURE_HW_SHUTDOWN#: length 66.7
  TOP w0.089: R4014.2 146.31,73.42 D4001.K 145.14,74.12 144.83,73.81 140.7,73.81 139.05,75.46 139.05,75.47 139.04,75.48 139.04,76.53 138.79,76.78 138.43,76.78 138.19,76.53 137.9,76.24 137.9,73.03 137.65,72.78 136.86,72.78 136.52,72.44 136.13,72.44 135.44,71.75 134.72,71.75 133.44,71.75 133.2,71.99 131.53,71.99 129.31,74.21 129.31,85.62 130.13,86.43 130.13,94.19 129.57,94.75 129.57,96.11 130,96.55 130.41,96.55 131.04,97.18 131.04,100.03 130.73,100.34 130.73,101.34 130.99,101.6 130.99,105.12 v2(130.61,105.51)
  BOTTOM w0.089: v2(130.61,105.51) 130.84,105.75 R2615.1 130.42,108.42 129.86,108.42 C2610.1 130.15,109.19 130.15,109.59 129.06,110.69 v1(129.06,111.2) 128.25,112.01 Q2602.D
PWR_1D05V_BST: length 2.5
  TOP w0.508: PC5204.1 v1(101.26,136.17) 99.77,136.17 v2(99.69,136.1)
PWR_1D05V_EN: length 4.5
  BOTTOM w0.089: PU5201.2 101.58,138.63 100.74,139.47 v1(100.46,139.47) 100.16,139.78 PC5215.1 100.16,141 99.49,141.66 PR5210.2
PWR_1D05V_FB: length 5.6
  BOTTOM w0.254: PR5202.2 102.42,140.31 PC5212.2 103.5,140.9 103.89,140.9 PR5204.1 103.89,140.78 v1(103.05,139.95) 103.08,139.92 103.08,138.78 103.08,138.78 PU5201.5
PWR_1D05V_FB_A: length 25.9
  L5 w0.254: v2(98.63,142.17) 98.67,142.17 99.32,141.52 99.32,141.11 101.09,139.34 101.09,138.63 102.06,137.66 103.47,137.66 106.84,134.29 106.84,130.94 105.92,130.02 105.92,127.38 v2(105.82,127.28)
  BOTTOM w0.254: v2(105.82,127.28) 105.82,127.28 ; 105.82,127.28 106.46,127.28 v1(106.5,127.24) ; 105.82,127.28 105.92,127.18 PG5223.1 ; PC5212.1 102.31,141.17 PR5202.1 101.68,141.65 101.01,142.32 98.78,142.32 v2(98.63,142.17)
PWR_1D05V_PFM#: length 2.5
  BOTTOM w0.254: PR5203.1 100.92,140.18 v1(101.86,139.24) 101.86,138.98 102.08,138.76 PU5201.3
PWR_1D05V_PH: length 2.9
  TOP w0.508: PC5204.2 102.15,134.61 102.29,134.47 v1(102.34,134.47) 102.32,134.49 100.49,134.49 v2(100.42,134.57)
PWR_1D05V_SS: length 2.2
  TOP w0.254: PC5213.1 100.38,138.13 v2(100.41,138.15) v1(100.99,138.41)
  BOTTOM w0.254: PU5201.22 v2(100.41,138.15)
PWR_1D05V_TON: length 2.1
  BOTTOM w0.254: v1(104.3,140.01) 103.56,139.27 PR5201.2 103.58,139.1 PU5201.6
PWR_1D8V: length 4.1
  BOTTOM w0.305: PR5305.1 69.17,40.92 PC5305.1 68,42.09 67.41,42.09 66.96,41.63 v2(66.37,41.63)
  vias: v1(66.14,40.34) v2(65.54,41.63)
PWR_1D8V_EN: length 4.4
  TOP w0.089: v2(68.13,39.6) 68.13,39.68 v1(68.51,40.06) 68.84,40.39 PC5307.1 PR5308.1
  BOTTOM w0.089: PU5301.7 68.26,38.17 67.97,38.46 67.97,39.45 v2(68.13,39.6)
PWR_1D8V_FB: length 3.7
  BOTTOM w0.254: v1(69.57,39.19) 69.8,39.42 PR5305.2 ; PU5301.1 70.51,39.47 70.59,39.55 70.31,39.55 PR5305.2 ; PR5305.2 69.7,40.16 PC5305.2
PWR_1D8V_PG: length 281.2
  TOP w0.089: v2(171.14,62.26) 171.53,62.65 171.53,63.11 171.43,63.22 171.43,63.75 171.96,64.28 171.96,68.44 171.73,68.67 171.73,72.56 v2(171.15,73.14) ; v2(72.57,38.61) v1(72.57,37.97)
  L3 w0.089: v2(99.11,39.57) 98.64,40.05 97.56,40.05 97.11,39.6 73.56,39.6 v2(72.57,38.61)
  L5 w0.089: v2(133.48,77.86) 133.43,77.92 133.43,85.83 132.86,86.4 132.86,89.85 131.84,90.87 131.84,93.05 131.42,93.48 131.42,96.59 131.27,96.73 131.27,98.93 130.84,99.37 130.84,104.6 129.19,106.25 129.19,108.26 130.15,109.22 131.7,109.22 132.49,110.01 132.49,112.82 120.57,124.74 119.83,124.74 v2(119.73,124.64)
  L6 w0.089: v2(171.14,62.26) 171.14,61.69 172.98,59.84 172.98,55.7 172.98,54.32 173.59,53.71 173.59,47.84 173.09,47.33 173.09,46.5 173.67,45.92 173.99,45.92 174.24,45.67 174.24,41.86 172.9,40.52 172.77,40.52 169.16,36.91 165.82,36.91 165.13,36.22 160.72,36.22 159.87,37.07 158.33,37.07 156.42,35.16 149.09,35.16 144.22,40.03 130.67,40.03 130.02,40.69 129.17,40.69 128.84,41.01 128.84,41.77 126.09,44.53 111.38,44.53 109.83,42.98 107.86,42.98 104.45,39.57 103.61,39.57 103.31,39.88 99.42,39.88 v2(99.11,39.57) ; v2(133.48,77.86) 133.48,76.79 133.94,76.33 133.94,75.9 135.1,74.74 160.15,74.74 161.65,73.25 165.09,73.25 165.49,72.85 170.86,72.85 v2(171.15,73.14) ; v2(119.73,124.64) 119.73,126.42 116.93,129.23 113.98,129.23 110.34,132.87 110.34,137.11 110.72,137.49 110.72,138.03 110.41,138.34 108.55,138.34 107.14,139.75 104.53,139.75 103.33,140.95 99.53,140.95 99.4,140.82 98.91,140.82 v2(98.73,140.64)
  BOTTOM w0.089: PR5210.1 98.89,140.79 v2(98.73,140.64) ; PU5301.2 72.13,38.17 v2(72.57,38.61) 73.36,38.61 PR5306.2
PWR_1D8V_PH: length 2.3
  BOTTOM w0.305: PU5301.6 67.9,37.67 67.2,36.97 PL5301.1
PWR_1D8V_VIN:
  vias: v1(72.77,37.8)
PWR_1D35V_BOOT_R: length 2.3
  BOTTOM w0.508: PC8619.1 113.41,147.63 PR8633.2 113.26,147.23 112.75,146.72 v1(112.75,146.41)
PWR_1D35V_BYP: length 3.4
  TOP w0.254: PR8634.1 111.74,153.11 v2(111.66,153.19)
  BOTTOM w0.254: PU8602.15 111.16,151.87 PC8633.1 PC8618.1 111.43,152.81 111.48,152.86 111.48,152.87 111.66,153.04 v2(111.66,153.19) v1(112.06,153.58)
PWR_1D35V_IMAX: length 2.8
  BOTTOM w0.254: PU8602.13 110.26,151.85 109.7,152.4 v1(109.45,152.4) 109.4,152.4 108.72,153.09 PR8632.2
PWR_1D35V_LDO_P5:
  vias: v1(112.75,152.15)
PWR_1D35V_PGOOD: length 6.4
  BOTTOM w0.089: v1(107.32,151.31) 107.89,151.31 108.31,150.89 ; v1(107.32,151.31) 107.32,152.25 PR8611.2 ; v1(107.32,151.31) 107.24,151.39 PR8630.2 ; 108.31,150.89 108.21,150.78 108.21,150.55 108.32,150.44 PU8602.9 ; 108.31,150.89 PU8602.10
PWR_1D35V_PHASE: length 5.7
  L3 w0.508: v2(113.39,149.96) 111.94,148.52 v2(108.33,148.52)
  vias: v1(112.78,149.79)
PWR_1D35V_VFB: length 3.7
  BOTTOM w0.254: PC8602.2 110.98,153.26 PR8627.2 ; PU8602.14 110.71,152.36 v1(110.67,152.4) 110.24,152.83 PR8627.2 ; PR8627.2 PR8626.1
PWR_1D35V_VFB1: length 9.1
  TOP w0.254: PG8613.2 v1(115.24,150.54) 113.86,150.54 112.5,151.89 112.5,153.24 111.61,154.13 111.59,154.13 v2(111,154.71)
  BOTTOM w0.254: v2(111,154.71) PC8602.1 110.98,154.13 PR8627.1
PWR_1V_VGA: length 4.4
  TOP w0.305: v2(113.8,140.77) 113.69,140.67 112.07,140.67 PC8632.1
  BOTTOM w0.305: PR8613.1 112.7,140.21 113.26,140.77 v2(113.8,140.77)
  vias: v1(115.7,144.15) v4(117,143.89) v4(117,143) v4(117,142.11)
PWR_1V_VGA_FB: length 4.7
  TOP w0.254: v1(109.5,142.14) 109.83,141.81 v2(109.83,141.48) 109.86,141.45 PC8632.2
  BOTTOM w0.254: PR8613.2 PR8620.1 111.58,141.07 110.66,142 PU8603.1 110.29,141.94 v2(109.83,141.48)
PWR_1V_VGA_VIN:
  vias: v1(108.28,141.53)
PWR_2D5V:
  vias: v1(90.35,36.37) v2(90.12,35.55)
PWR_2D5V_EN: length 4.5
  TOP w0.089: PC5127.1 PR5109.1 97.92,34.65 PR5117.1 98.56,34.06 v2(98.91,34.42) v1(98.91,33.83)
  BOTTOM w0.089: PU5101.8 v2(98.91,34.42)
PWR_2D5V_FB: length 5.1
  TOP w0.254: v1(91.62,33.71) PR5120.1 PR5119.2 91.62,35.94 v2(91.44,36.12) 91.85,36.53 PC5111.2
  BOTTOM w0.254: v2(91.44,36.12) 91.87,35.69 PU5101.2
PWR_2D5V_PG: length 4.4
  TOP w0.089: PR5112.2 99.57,35.99 PG5122.1 99.49,35.13 v2(99.55,35.08) 99.55,34.95 v1(99.88,34.62)
  BOTTOM w0.089: PU5101.7 99.06,35.69 99.55,35.21 v2(99.55,35.08)
PWR_3D3V_BOOT: length 2.9
  TOP w0.356: v1(57.92,130.56) v2(57.92,131.12)
  TOP w0.508: v2(57.92,131.12) 58.28,131.12 58.64,131.48 PR4501.1
  BOTTOM w0.254: PU4501.1 58.14,131.8 57.92,131.57 v2(57.92,131.12)
PWR_3D3V_BOOT_A: length 2.2
  TOP w0.508: PC4506.1 60.63,131.84 PR4501.2 v1(60.27,130.33)
PWR_3D3V_EN: length 4.2
  TOP w0.089: PR4508.1 60.97,135.04 PC4508.1 PR4509.2 61.78,134.65 v2(61.6,134.47) 61.72,134.34 v1(62.21,134.34)
  BOTTOM w0.089: PU4501.11 60.73,134.26 60.94,134.47 v2(61.6,134.47)
PWR_3D3V_EN1: length 5.8
  TOP w0.089: v1(64.14,132.51) 63.68,132.97 PR4516.2 63.25,133.83 v2(61.59,133.83) 61.4,133.64 PC4532.1 60.95,133.54 PR4514.1
  BOTTOM w0.089: PU4501.12 61.29,133.54 v2(61.59,133.83)
PWR_3D3V_FB: length 2.7
  TOP w0.254: PC4533.1 62.44,133.12 v1(62.46,133.15) 62.45,133.16 v2(61.57,133.16)
  BOTTOM w0.254: PU4501.13 61.3,133.09 61.38,133.16 61.56,133.16 61.56,133.16 v2(61.57,133.16)
PWR_3D3V_FB2: length 1.9
  TOP w0.254: PC4533.2 PR4506.2 63.78,130.94 v1(64.22,130.94)
PWR_3D3V_PH: length 7.3
  TOP w0.305: v2(58.83,130.58) 58.96,130.46 58.96,129.96 v1(59.23,129.69) 59.25,129.67 60.71,129.67 61.2,130.16 PC4506.2
  L6 w0.762: 58.02,132.97 58.83,132.16 v2(58.83,130.58)
  BOTTOM w0.254: PU4501.6 58.4,134.52 v2(58.02,134.52)
PWR_3D3V_VOUT: length 5
  TOP w0.254: v2(61.58,132.52) 61.58,132.21 62.07,131.72 PG4530.1 62.56,131.3 PR4506.1 63.35,130.33 63.81,129.87 v1(63.81,129.68)
  BOTTOM w0.203: v2(61.58,132.52) 61.58,132.53 61.47,132.64 PU4501.14
PWR_5V_BOOT: length 2.2
  TOP w0.254: PR4502.1 42.22,34.96 42.51,34.66 42.6,34.66 v2(42.64,34.62)
  TOP w0.356: v2(42.64,34.62) v1(43.23,34.67)
  BOTTOM w0.254: PU4502.1 42.49,34.77 v2(42.64,34.62)
PWR_5V_BOOT_A: length 2.2
  TOP w0.254: PR4502.2 40.2,34.65 PC4521.1
  TOP w0.356: PR4502.2 v1(40.43,36.1)
PWR_5V_EN: length 7.2
  BOTTOM w0.089: PR4511.2 35.82,38.08 35.82,38.76 PC4530.1 36.48,39.19 36.71,38.96 37.47,38.96 PR4512.1 38.48,38.41 v1(38.99,37.9) 39.25,37.9 39.43,38.08 40.11,38.08 40.28,37.9 PU4502.11
PWR_5V_EN1: length 7.1
  BOTTOM w0.089: PU4502.12 40.73,37.88 40.32,38.3 38.87,38.3 37.82,39.35 PC4531.1 PR4513.1 36.55,39.98 v1(36.18,39.98) 35.82,40.34 PR4504.2
PWR_5V_FB: length 3.6
  BOTTOM w0.254: PU4502.13 41.18,37.9 40.95,38.14 40.95,38.15 40.38,38.72 PC4526.1 39.61,38.74 PR4551.1 39.31,38.71 39.3,38.72 39.06,38.72 v1(38.69,39.09)
PWR_5V_FB_A: length 2.2
  TOP w0.254: v2(40.38,40.19) 40.38,39.78 40.51,39.66 v1(40.55,39.66) 41.24,39.66 PR4507.1
  BOTTOM w0.254: PC4526.2 v2(40.38,40.19)
PWR_5V_LDO: length 4.2
  TOP w0.254: v2(42.27,38.33) 42.84,37.76 v1(42.88,37.76)
  TOP w0.305: PG4528.1 43.96,37.76 v1(42.88,37.76)
  BOTTOM w0.254: PC4520.1 41.38,39.14 42.01,38.51 42.08,38.51 v2(42.27,38.33) 42.27,38.13 42.08,37.94 PU4502.15
PWR_5V_PH: length 7.1
  TOP w0.254: PC4521.2 39.39,35.56 v2(38.96,35.13)
  TOP w0.356: v2(43.61,35.31) v1(43.61,35.89)
  L5 w0.254: v2(43.61,35.31) 39.13,35.31 v2(38.96,35.13)
  BOTTOM w0.254: PU4502.6 39.03,35.17 38.99,35.13 v2(38.96,35.13)
PWR_5V_VOUT: length 4.1
  TOP w0.254: v2(41.45,38.35) 40.78,38.35 v1(40.74,38.39) 40.74,38.91 40.87,39.03 PR4507.2 41.49,39.04 PG4527.1
  BOTTOM w0.254: v2(41.45,38.35) 41.45,38.23 41.63,38.05 PU4502.14
PWR_BD_DET#: length 172.1
  TOP w0.089: AFTP6408.1 211.48,59.72 211.2,59.44 211.2,58.8 R2061.2 212.7,58.09 212.86,57.93 213.44,57.93 213.92,57.45 v2(213.92,57.43) ; v2(216.13,65.03) 215.14,66.02 211.15,66.02 210.82,66.35 191.59,66.35 190.5,65.26 190.5,63.99 187.71,61.2 183.26,61.2 180.7,63.76 180.7,63.9 180.7,63.91 180.7,66.91 176.36,71.25 176.36,72.95 167.67,81.64 167.67,83.37 167.29,83.75 167.29,83.77 v2(166.86,84.2)
  L5 w0.089: v2(132.54,96.47) 132.54,96.7 132.01,97.23 132.01,99.21 131.55,99.67 131.55,106.55 132.29,107.29 133.91,107.29 134.5,106.71 136.91,106.71 138,107.8 152.45,107.8 152.78,107.47 153.32,107.47 153.67,107.11 153.67,106.4 157.42,102.65 157.42,99.27 157.55,99.14 157.98,98.71 157.98,97.24 161.09,94.13 161.09,92.51 164.21,89.39 164.21,87 166.86,84.35 v2(166.86,84.2)
  L6 w0.089: v2(213.92,57.43) 213.92,56.92 214.73,56.11 216.13,56.11 218.37,58.35 219.92,58.35 220.75,59.17 220.75,61.24 217.87,64.12 217.04,64.12 v2(216.13,65.03)
  BOTTOM w0.089: v2(213.92,57.43) 213.95,57.4 PWR1.6 ; CPU1.CR14 116.88,98.34 117.55,97.66 117.55,97.52 118.22,96.86 119.1,96.86 119.28,96.67 120.59,96.67 120.84,96.92 120.84,96.93 121.87,97.97 124.62,97.97 124.74,97.84 129.54,97.84 130.15,97.62 131.3,96.47 v2(132.54,96.47)
PWR_CHG_ACIN: length 4.2
  TOP w0.254: v2(206.02,49.81) 206.01,49.82 205.86,49.82 205.26,50.43 PR4485.1 205.21,50.6 205.49,50.88 205.54,50.88 PR4484.2 v1(206.91,51.36)
  BOTTOM w0.203: PU4401.19 205.82,49.64 206,49.81 v2(206.02,49.81)
PWR_CHG_ACOK: length 382.4
  TOP w0.089: v2(14.35,125.25) 14.18,125.43 PR4499.2 ; v2(211.41,40.97) v1(210.37,40.97) 210.05,41.29 PG4408.1 208.48,41.29 PR4429.2 ; v2(206.25,47.43) 206.6,47.79 PR4426.1 207.06,47.78 PR4463.2
  L3 w0.089: v2(177.5,73.61) 181.13,71.15 182.04,70.23 182.04,69.72 183.26,68.51 186.03,68.51 186.14,68.48 186.69,68.37 187.31,68.1 189.6,65.81 209.6,65.81 210.35,66.56 220.32,66.56 221.38,67.62 223.32,67.62 224.03,66.9 224.03,61.85 223.09,60.91 223.09,40.87 223.83,40.13 223.83,39.46 v2(224.41,38.87)
  L5 w0.089: v2(206.25,47.43) 205.74,46.93 205.74,43.69 204.04,41.99 202.11,41.99 201.64,41.52 201.64,40.65 202.1,40.2 206.24,40.2 206.57,39.86 210.3,39.86 v2(211.41,40.97)
  L6 w0.089: v2(224.41,38.87) 223.73,38.19 223.73,37.57 221.62,35.47 219.36,35.47 216.72,38.1 215.63,38.1 212.76,40.97 v2(211.41,40.97) ; v2(177.5,73.61) 176.15,74.96 175.24,74.96 169.83,80.37 169.4,80.37 167.94,81.82 167.94,92.41 165.47,94.89 162.44,94.89 158.93,98.4 158.93,101.85 159.76,102.69 159.76,104.08 161.29,105.61 161.29,109.65 162.56,110.92 162.56,111.86 162.08,112.35 160.96,112.35 160.19,113.11 153.02,113.11 152.81,112.9 149.81,112.9 148.1,114.62 145.23,114.62 138.94,120.9 138.94,123.62 138.2,124.36 138.2,125.02 137.88,125.35 137.88,125.78 137.11,126.54 136.41,126.54 135.5,127.45 135.5,130.06 133.73,131.83 133.73,133.45 130.69,136.49 130.26,136.49 129.65,137.1 128.94,137.1 128.17,137.87 128.17,142.19 125.35,145.01 121.62,145.01 121.03,145.59 121.03,149.94 119.71,151.26 113.46,151.26 112.17,152.55 112.17,154.74 111.36,155.55 104.37,155.55 104.07,155.25 93.6,155.25 93.12,154.76 93.12,152.91 92.1,151.89 91.85,151.89 91.56,151.61 90.72,151.61 90.65,151.54 86.08,151.54 84.76,152.86 84.51,152.86 83.95,153.42 83.95,154.99 83.14,155.8 80.73,155.8 80.35,155.42 75.57,155.42 75.29,155.15 75.29,154.23 72.33,151.28 68.11,151.28 67.9,151.49 66.5,151.49 65.76,150.75 65.76,149.1 66.63,148.23 66.63,144.75 64.5,142.62 61.4,142.62 60.99,143.03 56.49,143.03 55.83,142.37 55.83,135.94 53.5,133.61 51.51,133.61 50.75,134.37 48.44,134.37 48.03,133.96 36.25,133.96 35.87,133.58 29.23,133.58 28.45,132.8 28.45,130.46 26.32,128.32 26.32,126.52 25.28,125.48 20.24,125.48 20.01,125.71 15.22,125.71 14.76,125.25 v2(14.35,125.25)
  BOTTOM w0.089: PU4401.24 206.05,47.64 v2(206.25,47.43)
PWR_CHG_ADP/ACIN: length 4.4
  TOP w0.254: PR4437.1 205.74,53.04 v1(205.74,53.57) ; PR4437.1 205.16,52.91 PR4434.1 ; PR4437.1 205.01,52.3 v2(205.01,52.05)
  BOTTOM w0.203: v2(205.01,52.05) 205.01,51.64 204.64,51.27 PU4401.16
PWR_CHG_AIN: length 22.1
  TOP w0.254: v2(207.18,53.81) 207.19,53.8 PR4404.1 208.06,53.19 v1(208.1,53.16)
  L5 w0.254: v2(207.18,53.81) 207.18,53.3 207.01,53.14 203.3,53.14 202.9,52.73 202.9,52.13 200.97,50.2 200.97,48.03 196.64,43.7 196.56,43.7 v2(195.58,42.72)
  BOTTOM w0.254: PR4465.2 193.94,42 PD4408.3 195.58,42.64 v2(195.58,42.72)
PWR_CHG_AIN_R: length 5.5
  TOP w0.254: v1(208.11,51.94) 207.72,52.33 PR4404.2 206.84,52.68 PR4437.2 206.25,52.46 PR4484.1 205.09,51.49 PC4420.2 204.4,51.51 PR4406.1
PWR_CHG_AMON: length 2.2
  BOTTOM w0.203: PR4412.2 v1(202.59,46.05) 202.59,46.15 203.04,46.6 PU4401.29
PWR_CHG_ASGATE: length 1.2
  TOP w0.254: TP4401.1 PR4490.2
PWR_CHG_ASGATE22: length 1.8
  BOTTOM w0.254: v1(197.34,51.08) 197.56,51.31 PC4442.2 198.32,51.22 PR4445.1
PWR_CHG_ASGATE/NTC: length 5.5
  TOP w0.254: v2(203.56,52.15) 203.03,52.15 PR4491.2 202.68,51.8 202.1,51.8 201.09,50.8 v1(200.8,50.8) 200.77,50.8 PR4490.1
  BOTTOM w0.203: PU4401.13 203.44,51.91 203.56,52.04 v2(203.56,52.15)
PWR_CHG_BATGONE: length 3.7
  TOP w0.254: v1(205.62,46.31) 205.13,46.31 v2(204.97,46.15) ; v1(205.62,46.31) 205.62,45.39 ; v1(205.62,46.31) 205.62,47.17 PC4430.1
  BOTTOM w0.203: v2(204.97,46.15) 204.81,46.15 204.64,46.33 PU4401.25
PWR_CHG_BGATE: length 30
  TOP w0.305: v1(178.26,34.57) 178.03,34.8 v2(177.7,34.8) 177.57,34.67 PC4429.1
  L6 w0.508: v2(177.7,34.8) 177.7,35.1 180.55,37.95 186.13,37.95 187.96,39.78 191.47,39.78 191.82,40.13 191.82,41.4 194.48,44.06 198.71,44.06 199.62,43.15 v2(199.62,42.88)
  BOTTOM w0.406: v2(177.7,34.8) 177.56,34.66 PU4412.4
  BOTTOM w0.508: PR4443.1 v2(199.62,42.88)
PWR_CHG_BGATE/HG2: length 1.3
  BOTTOM w0.254: PR4443.2 198.94,44.3 v1(198.61,44.3)
PWR_CHG_BGATE_22: length 2.9
  BOTTOM w0.254: PD4409.K 191.72,42.22 PR4464.1 191.72,44.1 PR4495.1 191.82,44.25 v1(192.56,44.25)
PWR_CHG_BGATE_22_R: length 18.9
  TOP w0.305: v1(177.12,36.1) 177.24,36.22 PC4443.2 178.1,36.41 v2(178.1,36.96) 178.07,36.98 PR4494.1
  L6 w0.508: v2(190.6,42.8) 190.6,42.39 190.15,41.94 184.37,41.94 181.66,39.22 180.36,39.22 v2(178.1,36.96)
  BOTTOM w0.254: PR4495.2 190.83,44.01 190.6,43.78 v2(190.6,42.8)
PWR_CHG_BOOT1: length 1.8
  BOTTOM w0.508: PR4402.2 200.71,53.52 v1(201.92,53.52) 202.29,53.14
PWR_CHG_BOOT2:
  vias: v1(199.61,48.54)
PWR_CHG_BT1_R:
  vias: v1(200.59,55.82)
PWR_CHG_BT2_R: length 2.9
  BOTTOM w0.508: PC4423.2 197.26,48.37 196.68,48.96 PR4444.2 196.09,50.04 v1(196.09,50.61)
PWR_CHG_CMRSC: length 4.9
  TOP w0.254: PR4439.2 197.01,51.38 v2(197.01,50.47) v1(197.01,49.71) 197.01,48.88 PR4438.1
  BOTTOM w0.254: v2(197.01,50.47) 197.08,50.39 PC4442.1
PWR_CHG_COMP: length 10.4
  TOP w0.254: PR4411.1 196.27,44.81 PC4433.1 196.27,44.13 v1(196.86,43.54) 197.03,43.54 198.38,44.88 202.27,44.88 v2(203.22,45.83)
  BOTTOM w0.203: v2(203.22,45.83) 203.22,46.27 203.44,46.49 PU4401.28
PWR_CHG_COMP_R: length 1.9
  TOP w0.254: v1(193.81,45.21) PC4431.1 194.9,45.01 PR4411.2
PWR_CHG_CSIN: length 10.4
  TOP w0.254: PR4489.2 200.2,56.21 200.78,56.21 202.07,54.92 202.97,54.92 203.1,55.05 203.1,55.47 v2(202.97,55.6)
  BOTTOM w0.203: 203.97,51.74 203.84,51.62 PU4401.14
  BOTTOM w0.254: 203.97,51.74 204.12,51.89 204.12,52.79 PC4415.1 203.11,53.8 PC4417.2 203.11,55.47 v2(202.97,55.6) 202.97,55.88 v1(202.59,56.26)
PWR_CHG_CSIN_R: length 11.3
  TOP w0.254: v2(184.94,55.47) v1(185.5,55.47) ; PR4423.1 192.71,55.76 192.47,55.53 189.64,55.53 189.06,54.94 v2(189.06,54.87)
  L3 w0.254: v2(189.06,54.87) 189.19,55 189.19,55.44 188.45,56.19 185.17,56.19 184.94,55.95 v2(184.94,55.47)
  BOTTOM w0.254: PG4402.2 184.94,56.16 v2(184.94,55.47)
PWR_CHG_CSIN_RR: length 6.1
  TOP w0.254: v1(196.88,56.59) 196.88,56.47 ; 196.88,56.47 199.08,56.47 PR4489.1 ; 196.88,56.47 194.97,56.47 194.13,55.63 193.72,55.63 PR4423.2
PWR_CHG_CSIP: length 11
  TOP w0.254: v1(204.17,55.65) v2(203.61,55.6) 203.48,55.47 203.48,54.89 203.13,54.54 201.91,54.54 200.62,55.83 200.2,55.83 PR4488.2
  BOTTOM w0.203: PU4401.15 204.24,51.48
  BOTTOM w0.254: 204.24,51.48 204.5,51.74 204.5,52.86 PC4415.2 204.17,54.06 PC4416.2 204.17,55.05 v2(203.61,55.6)
PWR_CHG_CSIP_R: length 11.8
  TOP w0.254: v2(184.28,55.47) v1(183.72,55.47) ; PR4422.1 192.56,55.14 190,55.14 v2(189.72,54.87)
  L3 w0.254: v2(189.72,54.87) 189.58,55 189.58,55.6 188.6,56.57 185.01,56.57 184.56,56.11 184.56,55.81 184.43,55.69 184.43,55.62 v2(184.28,55.47)
  BOTTOM w0.254: v2(184.28,55.47) 184.28,56.21 PG4401.2
PWR_CHG_CSIP_RR: length 6.3
  TOP w0.254: PR4422.2 193.86,55.25 194.29,55.25 195.13,56.08 198.17,56.08 ; 198.17,56.08 198.6,56.08 199.05,55.63 PR4488.1 ; 198.17,56.08 v1(198.17,55.98)
PWR_CHG_CSON: length 11.9
  TOP w0.254: PR4487.1 193.5,43.84 194.22,43.84 194.57,43.49 194.57,43.49 194.69,43.36 194.69,42.98 v2(194.82,42.85)
  BOTTOM w0.203: 198.94,45.56 198.98,45.6 199.04,45.7 200.98,47.64 PU4401.1
  BOTTOM w0.254: 198.94,45.56 198.52,45.13 197.96,45.13 PC4425.2 196.94,45.04 PC4426.2 195.74,45.04 194.69,43.99 194.69,43.51 v1(194.72,43.49) 194.69,43.46 194.69,42.98 v2(194.82,42.85)
PWR_CHG_CSON_R: length 13.4
  TOP w0.254: v2(172.72,40.95) 173.51,40.95 173.88,41.31 ; 173.88,41.31 174.2,41.63 179.98,41.63 180.97,42.62 184.25,42.62 PR4425.1 ; 173.88,41.31 v1(173.78,41.42)
  BOTTOM w0.254: PG4406.2 v2(172.72,40.95)
PWR_CHG_CSON_RR: length 8
  TOP w0.254: v1(189.41,44.1) 189.41,44.02 ; 189.41,44.02 189.1,44.02 187.7,42.62 185.52,42.62 PR4425.2 ; 189.41,44.02 191.65,44.02 191.8,43.87 192.36,43.87 PR4487.2
PWR_CHG_CSOP: length 12
  TOP w0.254: v2(194.19,42.85) 194.19,43.33 194.06,43.46 193.58,43.46 PR4486.1
  BOTTOM w0.203: 198.76,45.92 198.83,45.92 200.95,48.04 PU4401.2
  BOTTOM w0.254: 198.76,45.92 198.36,45.52 197.78,45.52 PC4425.1 196.34,45.9 PC4424.2 196.01,46.1 195.23,45.31 195.23,45.15 v1(194.78,44.7) 194.29,44.21 194.29,42.95 v2(194.19,42.85)
PWR_CHG_CSOP_R: length 11.7
  TOP w0.254: v1(175.31,41.17) 175.31,41.25 ; 175.31,41.25 174.55,41.25 v2(174.25,40.95) ; 175.31,41.25 180.14,41.25 181.13,42.24 184.25,42.24 PR4424.1
  BOTTOM w0.254: PG4405.2 v2(174.25,40.95)
PWR_CHG_CSOP_RR: length 8.2
  TOP w0.254: v1(188.85,42.98) 188.73,43.11 ; 188.73,43.11 187.86,42.24 185.52,42.24 PR4424.2 ; 188.73,43.11 189.26,43.64 191.49,43.64 191.65,43.49 192.23,43.49 PR4486.2
PWR_CHG_DCIN: length 4.9
  BOTTOM w0.203: PU4401.17 205.2,50.82
  BOTTOM w0.254: v1(205.67,52.3) 206.05,52.68 PR4403.1 206.81,52.6 PC4419.1 205.59,51.2 205.2,50.82
PWR_CHG_DCIN_R: length 28
  TOP w0.254: v1(207.78,54.33) v2(207.98,53.8)
  L5 w0.254: v2(197.64,43.11) 197.41,43.33 197.41,43.51 201.48,47.58 201.48,49.99 203.13,51.64 203.77,51.64 204.07,51.94 204.07,52.36 204.27,52.55 207.21,52.55 207.98,53.32 v2(207.98,53.8)
  L6 w0.254: v2(197.64,43.11) 197.56,43.03 197.56,42.54 197.44,42.41 196.29,42.41 195.71,41.84 193.86,41.84 v2(192.66,40.63)
  BOTTOM w0.254: v2(207.98,53.8) 208.41,53.37 PR4403.2 ; PD4407.K 191.62,39.68 192.58,40.63 v2(192.66,40.63) ; PD4401.3 198.28,43.11 v2(197.64,43.11)
PWR_CHG_HG1_R: length 2.8
  TOP w0.406: v1(191.11,52.2) v2(191.81,51.98) 192.17,51.61 PR4414.2
  BOTTOM w0.406: PU4403.4 v2(191.81,51.98)
PWR_CHG_HG2_R: length 2.2
  TOP w0.356: v2(184.92,44.12) v1(184.31,43.77)
  TOP w0.508: PR4420.2 185.5,44.04 185,44.04 v2(184.92,44.12)
  BOTTOM w0.406: v2(184.92,44.12) 184.87,44.07 PU4405.4
PWR_CHG_LGATE1: length 10.6
  L3 w0.635: v4(200.82,51.83) 200.52,51.54 196.85,51.54 193.33,48.02 v4(191.76,48.02)
  vias: v1(191.01,48.19)
PWR_CHG_LGATE2: length 3.2
  TOP w0.356: v1(182.07,45.96) PR4446.1
  TOP w0.635: v4(181.33,44.17) 182.03,44.87 PR4446.1
  BOTTOM w0.406: PU4406.4 181.23,44.07 v4(181.33,44.17)
PWR_CHG_LGATE2/ASGATE: length 22.4
  TOP w0.356: v1(184.34,46.03) v4(183.7,45.81)
  TOP w0.508: PR4446.2 v4(183.7,45.81)
  L3 w0.635: v4(183.7,45.81) 185.03,47.14 190.24,47.14 191.78,45.59 196.25,45.59 197.36,46.7 197.36,49.18 198.5,50.32 199.39,50.32 v4(199.77,50.7)
PWR_CHG_NGATE: length 3.6
  TOP w0.381: PR4480.1 v1(199.09,47.45) 199.52,47.45 v4(199.85,47.78) 200.48,48.4 PR4453.2
PWR_CHG_NTC: length 2
  TOP w0.254: PR4491.1 202.2,51.16 v1(202.01,50.97) 201.63,50.59 PR4492.1
PWR_CHG_OTGEN: length 6.4
  TOP w0.254: v1(207.96,49.91) v2(207.65,49.23) 207.41,49.47 PR4449.2 206.9,49.35 206.27,49.35 206.23,49.3 206.15,49.3 205.72,48.87 PR4417.2 PR4451.1
  BOTTOM w0.203: PU4401.20 205.91,49.24 205.95,49.28 207.01,49.28
  BOTTOM w0.254: v2(207.65,49.23) 207.31,49.23 207.26,49.28 207.01,49.28
PWR_CHG_OTGPG: length 14.1
  TOP w0.254: PR4447.1 195.08,38.58 PR4448.2 195.13,39.55 TP4411.1 197.25,39.55 198.62,40.93 199.21,40.93 v2(203.82,45.53)
  BOTTOM w0.203: v2(203.82,45.53) 203.98,45.53 204.3,45.85 204.3,46.48 204.24,46.54 PU4401.26
PWR_CHG_PHASE1: length 11.1
  TOP w0.356: v4(201.19,52.59) v1(200.66,53.01)
  TOP w0.635: v4(195.08,52.12) 194.88,51.93 PR4416.1
  L3 w0.635: v4(201.19,52.59) 201.08,52.71 195.66,52.71 v4(195.08,52.12)
  BOTTOM w0.508: PC4436.1 199.65,53.96 199.65,53.09 200.15,52.59 v4(201.19,52.59)
PWR_CHG_PHASE2: length 20.3
  TOP w0.356: v4(184.89,44.98) v1(185.52,45.44)
  TOP w0.508: PR4441.1 199.19,49.17 v4(199.22,49.15)
  L3 w0.635: v4(184.89,44.98) 185.83,45.92 189.28,45.92 190.76,44.45 196.73,44.45 198.91,46.64 198.91,48.85 v4(199.22,49.15)
PWR_CHG_PHASE2_R: length 3.3
  TOP w0.508: v4(200.26,49.84) 200.16,49.94 199.24,49.94 198.84,50.43 198.78,50.49 PR4441.2 v1(198.06,51.52)
PWR_CHG_PROCHOT#: length 3.1
  BOTTOM w0.127: PQ4416.2 207.52,47.65 PR4435.2 206.68,48.04 206.63,47.99 v1(206.14,47.99) 206.1,48.04 PU4401.23
PWR_CHG_PROCHOT#_R: length 87.7
  TOP w0.127: v2(173.79,73.81) 173.79,74.55 173.16,75.18 172.67,75.18 172.41,74.92 171.54,74.92 169.7,76.76 169.7,77.55 170.12,77.97 170.12,78.83 167.41,81.54 167.41,83.29 167.17,83.54 v2(166.86,83.54) ; PR4472.2 207.02,45.44 206.31,46.15 206.27,46.15 v2(206.26,46.16)
  L3 w0.127: v2(173.79,73.81) 173.79,73.62 175.15,72.26 175.15,70.41 177.31,68.25 178.64,68.25 180.25,66.64 180.25,63.52 184.05,59.72 197.67,59.72 198.68,58.7 205.77,58.7 207.85,56.62 207.85,54.59 207.6,54.33 205.95,54.33 205.82,54.2 205.82,52.58 206.34,52.06 206.34,51.32 208.16,49.51 208.16,48.06 v2(206.26,46.16)
  BOTTOM w0.127: PQ4402.G 160.8,92.92 160.4,92.53 v1(160.4,92.38) 160.4,90.32 161.78,88.95 163.96,88.95 166.09,86.82 166.09,84.3 v2(166.86,83.54)
PWR_CHG_PROG: length 11
  TOP w0.254: PR4493.1 197.35,45.77 v1(197.36,45.78) 199.51,45.78 199.89,45.4 202.02,45.4 202.9,46.27 202.9,47.1 PR4410.2 203.56,47.26 203.56,47.21 PC4441.1 204.07,46.42 v2(203.81,46.16)
  BOTTOM w0.203: v2(203.81,46.16) 203.84,46.19 PU4401.27
PWR_CHG_PSYS: length 7.7
  TOP w0.089: PR4442.1 198.15,46.69 v1(198.36,46.47) 199.61,46.47 PR4413.1 201.02,47.41 201.02,46.74 v2(201.83,45.92)
  BOTTOM w0.089: PU4401.30 202.64,46.66 201.91,45.92 v2(201.83,45.92)
PWR_CHG_SNB: length 2.6
  TOP w0.254: v1(193.79,49.68) PR4416.2 195.62,49.72 195.89,49.98 PC4435.1
PWR_CHG_UGATE1: length 10.5
  TOP w0.356: v4(202.02,52.41) v1(202.36,53.04)
  TOP w0.762: PR4414.1 195.77,53.29 v4(195.98,53.51)
  L3 w0.635: v4(202.02,52.41) 202.02,52.86 202.01,52.87 202.01,52.98 201.55,53.44 196.05,53.44 v4(195.98,53.51)
PWR_CHG_UGATE2: length 20.8
  TOP w0.381: v4(200.1,49) 199.38,48.28 PR4438.2
  TOP w0.762: v1(188.42,45.59) v4(187.86,45.09) PR4420.1
  L3 w0.635: v4(187.86,45.09) 188.88,45.09 190.3,43.66 194.77,43.66 194.79,43.68 195.36,43.68 195.38,43.66 197.06,43.66 200.74,47.35 200.74,48.36 v4(200.1,49)
PWR_CHG_VBAT1: length 3.8
  BOTTOM w0.203: PU4401.31 202.24,46.71 201.99,46.46
  BOTTOM w0.254: PR4478.1 200.76,45.1 PC4440.2 201.58,45.41 201.18,45.81 PC4445.1 201.6,46.46 201.99,46.46
PWR_CHG_VBATIN_R: length 16.9
  TOP w0.508: PR4480.2 195.56,47.45 v2(195.23,47.12)
  L5 w0.508: v2(181.71,40.18) 181.79,40.18 184.13,42.52 186.97,42.52 189.46,45.01 194.08,45.01 194.74,45.67
PWR_CHG_VDDP:
  vias: v1(199.77,52.12)
PWR_DCBATOUT_1D05V:
  vias: v1(105.32,136.63) v4(106.61,136.5) v4(107.39,136.15)
PWR_DCBATOUT_1D35V:
  vias: v1(110.77,147.6) v4(108.89,147.65) v4(109.88,147.65)
PWR_DCBATOUT_VCCGTA:
  vias: v1(80.65,142.04) v2(78.9,136.68) v2(79.96,141.45) v2(84.33,136.17) v2(84.99,136.17) v4(79.99,140.41) v4(79.99,139.32) v4(87.68,141.66) v4(87.68,140.82) v4(87.68,139.98) v4(88.42,141.25)
PWR_DCBATOUT_VCCSA: length 0.6
  TOP w0.356: AFTP5001.1 v2(93.23,138.28)
PWR_DCBATOUT_VCORE:
  vias: v1(69.55,138.48) v4(69.12,139.04) v4(69.12,137.95) v4(70.11,140.11) v4(70.06,139.04) v4(70.07,137.95)
PWR_DCBATOUT_VDDQ: length 1.6
  TOP w0.254: PR5106.1 115.78,29.95 v2(116.59,30.76)
  vias: v1(117.33,33.78) v4(117.73,32.21) v4(118.57,32.23) v4(119.46,32.21)
PWR_LED#: length 7.9
  TOP w0.254: U2402.4 v1(47.12,54.73) 47.38,54.73 48.29,55.64 Q6402.S 50.1,59.13 R6412.1
PWR_LED#_C: length 3.3
  TOP w0.254: v2(212.61,57.48) 212.32,57.19 R6410.2 212.55,56.49 AFTP6407.1
  BOTTOM w0.254: PWR1.4 212.95,57.08 212.61,57.42 v2(212.61,57.48)
PWR_LED#_Q: length 164.5
  TOP w0.254: v2(114.84,69.78) 114.84,69.09 106.54,60.79 101.11,60.79 100.83,60.5 99.52,60.5 99.34,60.68 53.85,60.68 52.53,59.36 R6412.2 50.65,58.27 Q6402.D ; v2(179.22,66.49) v1(178.97,65.99)
  L3 w0.254: v2(179.22,66.49) 179.22,65.89 179.55,65.56 179.55,63.23 183.76,59.02 194.67,59.02 195.35,58.34 195.35,58.09 195.28,58.02 195.28,57.23 196.31,56.2 196.87,56.2 v2(197.59,55.47)
  BOTTOM w0.254: Q6405.B 198.02,54.77 197.59,55.2 v2(197.59,55.47) ; v2(114.84,69.78) 115.59,69.78 118.05,67.32 127.64,67.32 128.37,66.59 168.5,66.59 170.18,64.91 170.18,64.67 170.56,64.29 172.9,64.29 175.03,66.42 179.15,66.42 v2(179.22,66.49)
PWR_LED#_R: length 16.6
  TOP w0.254: R6410.1 211.46,57 210.7,57.76 v2(210.57,57.76) ; v2(202.82,57.2) v1(202.6,56.69)
  L6 w0.254: v2(210.57,57.76) 209.91,58.42 204.57,58.42 204.04,57.89 203.51,57.89 v2(202.82,57.2)
  BOTTOM w0.254: v2(202.82,57.2) 202.59,57.2 201.93,56.54 EC6405.1 Q6405.C
PWR_LEVEL: length 23.3
  TOP w0.089: v2(149.61,114.11) v1(150.17,114.11)
  L5 w0.089: v2(135.34,121.46) 134.75,121.46 134.28,121 134.28,120.03 137.16,117.15 143.2,117.15 146.16,114.18 149.54,114.18 v2(149.61,114.11)
  BOTTOM w0.089: v2(149.61,114.11) 149.13,113.63 R7905.2 149.36,113.24 D7902.A ; GPU1.D7 v2(135.34,121.46)
PWR_VCCGT_BOOTA: length 3
  BOTTOM w0.305: PU4801.5 83.84,138.23 v1(83.26,138.81) 83.21,138.81 83.13,138.89 82.7,139.07
  BOTTOM w0.508: 82.7,139.07 82.37,139.4 PR4804.2
PWR_VCCGT_BOOTA_RC: length 2.4
  BOTTOM w0.254: v1(84.33,142.17) 83.54,141.38 PC4808.1
  BOTTOM w0.508: PR4804.1 PC4808.1
PWR_VCCGT_BOOTB: length 2.6
  TOP w0.254: v1(76.97,138.74) 77.1,138.74 v2(77.5,138.34)
  TOP w0.508: v2(77.5,138.34) 77.07,137.91 PR4810.2
  BOTTOM w0.305: v2(77.5,138.34) 77.5,138.33 77.52,138.31 PU4802.5
PWR_VCCGT_BOOTB_RC: length 2.7
  TOP w0.508: PC4811.1 PR4810.1 76.66,136.02 76.05,135.41 v1(76.05,135.13)
PWR_VCCGT_BOOTRA: length 2.8
  BOTTOM w0.305: PU4801.7 84.84,138.38 v1(84.51,138.71)
  BOTTOM w0.508: v1(84.51,138.71) 83.54,139.68 PC4808.2
PWR_VCCGT_BOOTRB: length 2.5
  TOP w0.254: v1(78.44,138.91) 78.22,138.7 v2(78.22,138.37)
  TOP w0.508: PC4811.2 78.22,137.4 v2(78.22,138.37)
  BOTTOM w0.305: v2(78.22,138.37) 78.52,138.07 PU4802.7
PWR_VCCGT_COMP: length 4.9
  TOP w0.254: PC4610.2 82.22,149.4 v1(82.68,149.4) v2(83.44,149.4) 83.44,150.12 PR4626.2
  BOTTOM w0.203: v2(83.44,149.4) 83.3,149.55 PU4601.4
PWR_VCCGT_COMP1: length 4.6
  TOP w0.254: v1(87.87,151.03) 87.86,151.03 87.24,150.41 PC4612.1 86.98,150.42 PC4651.1 85.75,150.88 84.38,150.88 84,150.5 PR4626.1
PWR_VCCGT_FB: length 5.9
  TOP w0.254: PR4630.2 PR4633.2 PR4636.2 84.94,149.58 84.38,149.58 v2(84.2,149.4) 83.81,149.01 v1(83.81,148.94)
  BOTTOM w0.203: PU4601.5 82.43,149.15
  BOTTOM w0.254: v2(84.2,149.4) 83.7,148.9 83.11,148.9 82.86,149.15 82.43,149.15
PWR_VCCGT_FB1: length 1.6
  TOP w0.254: v1(86.31,147.09) 86.49,147.28 PC4614.1 PR4630.1
PWR_VCCGT_FB2: length 8
  TOP w0.254: PR4633.1 85.96,148.64 86.57,148.64 PC4618.2 86.95,148.67 v2(87.4,149.12) 87.73,148.79 PC4615.2 88.19,148.79 PR4631.1 89.24,147.88 v1(90,148.64)
  BOTTOM w0.254: v2(87.4,149.12) 88.36,149.12 88.73,149.48 PC4619.1 89.56,149.86 PR4665.2
PWR_VCCGT_FB_RC: length 1.7
  TOP w0.254: v1(87.48,149.67) 87.09,149.67 87,149.58 PC4618.1 85.86,149.58 PR4636.1
PWR_VCCGT_FCCM#: length 3
  BOTTOM w0.203: PR4806.2 v1(81.77,145.7) 81.69,145.7 81.13,146.26 PU4601.11
  BOTTOM w0.254: PR4806.2 PR4812.2
PWR_VCCGT_FCCM#_RA: length 9.2
  TOP w0.254: v1(82.57,143.7) 81.99,143.7 81.56,143.27 v2(81.56,143.18)
  L5 w0.254: v2(81.56,143.18) 81.56,142.98 81.11,142.52 81.11,138.15 v2(81.16,138.1)
  BOTTOM w0.254: PU4801.2 82.34,138.16 82.1,138.41 81.46,138.41 v2(81.16,138.1) ; PR4806.1 81.77,143.67 v2(81.56,143.18)
PWR_VCCGT_FCCM#_RB: length 14.2
  TOP w0.254: v1(75.38,138.7) 75.39,138.68 75.39,138.66 75.71,138.34 v2(75.8,138.34)
  L5 w0.254: v2(82.23,143.17) 82.23,142.9 81.69,142.37 81.69,137.92 81.3,137.53 80.24,137.53 79.95,137.82 75.97,137.82 75.8,137.99 v2(75.8,138.34)
  BOTTOM w0.254: v2(82.23,143.17) 82.55,143.5 PR4812.1 ; v2(75.8,138.34) 75.8,138.32 75.9,138.23 76.02,137.94 PU4802.2
PWR_VCCGT_IMON: length 6
  TOP w0.203: PC4604.2 81.82,150.78 v1(81.92,150.88) v2(82.48,150.88)
  BOTTOM w0.203: 83.16,150.88 v2(82.48,150.88) 82.48,150.47 82.36,150.35 PU4601.2
  BOTTOM w0.254: PR4608.2 85.7,150.88 83.16,150.88
PWR_VCCGT_ISEN1: length 11.5
  TOP w0.254: PC4625.1 87.44,145.51 87.38,145.44 v2(87.36,145.44) 87.1,145.44 v1(86.74,145.09) 86.18,144.53 PR4824.2
  L5 w0.254: v2(87.36,145.44) 87.36,146.1 86.59,146.87 83.8,146.87 83.8,146.86 v2(83.52,146.86)
  BOTTOM w0.203: PU4601.9 82.3,147.55 PR4669.2
  BOTTOM w0.254: v2(87.36,145.44) 86.54,145.44 PR4821.1 ; PR4669.2 83.31,147.07 v2(83.52,146.86)
PWR_VCCGT_ISEN2: length 18.8
  TOP w0.254: PR4823.1 84.86,142.77 85.22,142.42 85.98,142.42 86.67,143.1 PR4822.2 87.18,142.78 88.1,142.78 v1(89.18,143.86) 89.64,144.32 PR4670.1 89.64,145.22 v2(89.42,145.44) 89.26,145.44 89.19,145.51 PC4626.1
  L5 w0.254: v2(83.52,146.18) 83.7,146.36 84.01,146.36 84.01,146.36 86.38,146.36 86.85,145.89 86.85,145.23 87.14,144.93 88.91,144.93 v2(89.42,145.44)
  BOTTOM w0.203: PR4669.1 82.53,146.2 82.27,146.46 82.27,147.02 82.14,147.15 PU4601.10
  BOTTOM w0.254: v2(83.52,146.18) 83.49,146.2 PR4669.1
PWR_VCCGT_ISUMN: length 35.4
  TOP w0.254: v2(90.43,146.99) 90.43,146.44 90.15,146.16 PR4647.1 89.05,146.16 PC4626.2 PC4625.2 87.94,146.37 PC4633.1 86.67,145.85 v2(85.68,145.85) 85.11,145.85 85.05,145.89 PR4643.2 85,146.72 PC4630.2 ; AFTP4603.1 v2(88.24,129.41)
  L3 w0.254: v2(85.63,143) 85.69,143 86.19,143.5 86.19,145.54 85.88,145.85 v2(85.68,145.85)
  L5 w0.254: v2(88.24,129.41) 88.03,129.41 87.02,130.42 87.02,133.3 87.3,133.58 87.3,138.3 89.41,140.41 89.41,143.49 89.94,144.03 89.94,146.51 v2(90.43,146.99)
  BOTTOM w0.254: PR4809.2 85.82,143.13 85.69,143 v2(85.63,143) ; v2(85.68,145.85) 85.45,146.08 PR4642.2 85.05,146.02 PR4645.2 84.89,145.16 PR4815.2 ; v2(88.24,129.41) 88.66,129 PR4646.2
PWR_VCCGT_ISUMN_GA: length 22.4
  TOP w0.254: v2(84.74,127.97) v1(85.3,127.97) ; v2(88.24,143.64) 88.12,143.51 87.76,143.51 PR4822.1
  L5 w0.254: v2(84.74,127.97) 84.56,128.14 84.56,129.1 86.39,130.93 86.39,133.86 86.24,134.02 86.24,141.93 86.39,142.08 86.39,142.44 87.73,143.79 88.09,143.79 v2(88.24,143.64)
  BOTTOM w0.254: PR4809.1 86.57,144.17 87.13,144.17 87.51,143.79 88.09,143.79 v2(88.24,143.64) ; PG4809.1 84.46,127.69 v2(84.74,127.97)
PWR_VCCGT_ISUMN_GB: length 31.2
  TOP w0.254: v2(83.28,143.82) 83.52,144.05 83.52,144.1 83.67,144.25 83.72,144.25 PR4824.1 ; v2(77.3,127.89) v1(77.47,128.45)
  L5 w0.254: v2(83.28,143.82) 83.4,143.82 84.03,143.19 84.03,142.49 83.75,142.21 83.75,137.07 82.13,135.46 80.15,135.46 79.95,135.66 74.62,135.66 73.99,135.04 73.99,129.6 74.5,129.09 76.57,129.09 77.17,128.49 77.17,128.01 v2(77.3,127.89)
  BOTTOM w0.254: PG4815.1 76.84,127.43 v2(77.3,127.89) ; PR4815.1 83.66,144.2 v2(83.28,143.82)
PWR_VCCGT_ISUMN_P_1: length 7.3
  TOP w0.254: v2(88.88,147.04) 89.03,147.04 89.05,147.02 PR4647.2 90.11,147.48 90.97,147.87 v1(90.99,147.87)
  BOTTOM w0.254: PC4628.2 86.26,149.25 PC4653.2 86.26,147.72 ; 86.26,147.72 86.26,147.63 87.3,146.58 88.43,146.58 88.88,147.03 v2(88.88,147.04) ; 86.26,147.72 PC4654.2
PWR_VCCGT_ISUMN_P_2: length 21.6
  TOP w0.254: AFTP4604.1 v2(88.27,130.05) ; PR4641.2 v2(91.95,147.01)
  L5 w0.254: v2(91.95,147.01) 92.36,146.59 92.36,145.73 89.92,143.28 89.92,140.2 87.81,138.09 87.81,133.32 87.53,133.05 87.53,130.63 88.12,130.05 v2(88.27,130.05)
  BOTTOM w0.254: v2(88.27,130.05) 88.78,130.05 PR4646.1
PWR_VCCGT_ISUMN_RC: length 1.7
  BOTTOM w0.254: PC4623.1 84.22,145.35 PR4645.1 83.36,145.32 v1(83.32,145.37)
PWR_VCCGT_ISUMNB: length 4.8
  BOTTOM w0.203: 82.81,147.55 82.41,147.95 PU4601.8
  BOTTOM w0.254: v1(84.53,147.83) 84.53,147.75 85,147.28 PR4642.1 84.29,146.94 PC4623.2 83.68,147.55 82.81,147.55
PWR_VCCGT_ISUMP: length 22.8
  TOP w0.254: v1(91.86,145.41) v2(91.86,146.14) PR4641.1 ; v2(85.67,145.21) 85.45,145.21 85.35,145.11 84.96,145.11 PR4643.1 84.06,146.01 PC4630.1 84.06,148.32 v2(84.13,148.39) ; v2(85.58,143.66) 85.93,144.02 86.49,144.02 86.52,144.04 86.59,144.04 86.62,144.07 PR4808.1
  BOTTOM w0.203: PU4601.7 82.48,148.35 82.92,147.91 83.65,147.91 v2(84.13,148.39)
  BOTTOM w0.254: v2(91.86,146.14) 88.84,146.14 88.65,145.95 86.99,145.95 86.05,146.89 85.87,147.1 PC4654.1 85.34,147.72 PC4653.1 85.34,149.25 PC4628.1 84.99,149.25 v2(84.13,148.39) ; PR4816.1 84.86,143.31 85.22,143.66 v2(85.58,143.66) 85.58,145.01 85.67,145.11 v2(85.67,145.21)
PWR_VCCGT_ISUMP_GA: length 23
  TOP w0.254: v2(88.24,144.3) 88.14,144.2 87.66,144.2 PR4808.2 ; v1(83.47,127.97) v2(84.03,127.97)
  L5 w0.254: v2(84.03,127.97) 84.18,128.12 84.18,129.26 86.01,131.09 86.01,133.71 85.86,133.86 85.86,142.09 86.01,142.24 86.01,142.6 87.58,144.17 88.12,144.17 v2(88.24,144.3)
  BOTTOM w0.254: PG4808.1 84.46,128.47 84.03,128.04 v2(84.03,127.97) ; PR4821.2 86.57,144.55 87.28,144.55 87.66,144.17 88.12,144.17 v2(88.24,144.3)
PWR_VCCGT_ISUMP_GB: length 30.3
  TOP w0.254: PR4823.2 83.86,143.6 83.78,143.6 v2(83.34,143.16) ; v1(75.95,128.32) v2(76.53,127.92)
  L5 w0.254: v2(83.34,143.16) 83.52,143.16 83.65,143.03 83.65,142.65 83.37,142.37 83.37,137.23 81.97,135.84 80.31,135.84 80.11,136.04 74.46,136.04 73.61,135.19 73.61,129.44 74.34,128.71 76.42,128.71 76.79,128.34 76.79,128.17 v2(76.53,127.92)
  BOTTOM w0.254: v2(83.34,143.16) 83.47,143.28 PR4816.2 ; v2(76.53,127.92) 76.84,128.22 PG4813.1
PWR_VCCGT_NTC: length 1.3
  BOTTOM w0.203: PU4601.3 82.61,149.95 82.7,150.04 PR4616.1
PWR_VCCGT_NTC1: length 17.3
  TOP w0.254: v1(85.22,150.45) 85.04,150.27 v2(84.53,150.27)
  L5 w0.254: v2(84.53,150.27) 82.58,150.27 81.89,149.58 81.89,144.98 80.27,143.36 v2(80.27,143.16)
  BOTTOM w0.254: PR4616.2 84.08,150.27 v2(84.53,150.27) 85.55,150.27 PR4621.2 ; PR4617.1 80.85,142.34 80.27,142.93 v2(80.27,143.16)
PWR_VCCGT_PWMA: length 2.2
  BOTTOM w0.203: PU4601.12 80.73,146.15 80.95,145.92 80.98,145.92 81.26,145.64 81.26,145.14 80.98,144.86 PR4802.2
PWR_VCCGT_PWMA_RA: length 8.3
  TOP w0.254: v1(81.28,143.71) 80.93,143.36 v2(80.93,143.18)
  L5 w0.254: v2(80.45,138.03) 80.6,138.18 80.6,142.73 80.93,143.06 v2(80.93,143.18)
  BOTTOM w0.254: v2(80.45,138.03) 80.89,137.59 81.38,137.59 81.47,137.68 PU4801.1 ; v2(80.93,143.18) 80.98,143.23 PR4802.1
PWR_VCCGT_PWMB: length 3.5
  TOP w0.254: PR4811.2 81.97,145.19 81.69,144.91 v1(81.51,144.91) 81.49,144.93 81.23,144.93 80.78,145.39 v2(80.78,145.44)
  BOTTOM w0.203: PU4601.13 80.33,146.07 80.78,145.62 v2(80.78,145.44)
PWR_VCCGT_PWMB_RA: length 17.7
  TOP w0.254: PR4811.1 82.73,145.7 v1(82.73,144.91) 83.11,144.53 v2(83.19,144.53)
  L5 w0.254: v2(75.07,138.2) 75.15,138.13 75.15,137.93 75.76,137.31 79.74,137.31 80.03,137.02 81.55,137.02 82.2,137.67 82.2,142.16 82.76,142.72 82.76,144.1 v2(83.19,144.53)
  BOTTOM w0.254: PU4802.1 75.52,137.9 75.22,138.2 v2(75.07,138.2)
PWR_VCCGT_RTN: length 12.2
  TOP w0.254: v2(83.44,148.39) 83.24,148.18 PC4622.1 81.76,148.31 PR4639.1
  L5 w0.254: v2(88.04,150.4) 88.02,150.4 88.01,150.39 87.1,150.39 85.6,148.9 83.85,148.9 83.44,148.49 v2(83.44,148.39)
  BOTTOM w0.203: v2(83.44,148.39) 82.91,148.39 82.55,148.75 PU4601.6
  BOTTOM w0.254: v1(87.76,150.93) v2(88.04,150.4) 88.06,150.4 88.06,150.39 88.34,150.39 PC4619.2 88.81,150.69 PR4666.2
PWR_VCCGT_SNB1: length 2.4
  TOP w0.508: v1(86.49,131.75) PC4810.1 85.52,130.58 PR4805.2
PWR_VCCGT_SNB2: length 2.4
  TOP w0.508: v1(74.04,131.62) PC4813.1 75.21,131.52 PR4814.2
PWR_VCCGT_SWA: length 1.6
  TOP w0.305: v1(81.54,130.99) v2(81.69,130.43)
  TOP w0.508: PR4805.1 v2(81.69,130.43)
PWR_VCCGT_SWB: length 1.9
  TOP w0.305: v2(78.92,130.02) v1(78.98,129.21)
  TOP w0.508: PR4814.1 v2(78.92,130.02)
PWR_VCCGT_VCCDA: length 5.2
  TOP w0.508: PC4809.1 79.53,137.67 PR4803.1 81.67,137.21 v2(82.84,138.39)
  BOTTOM w0.305: PU4801.3 v2(82.84,138.39)
PWR_VCCGT_VCCDB: length 1.4
  BOTTOM w0.305: PU4802.3 76.52,138.28 v2(76.46,138.34) 76.59,138.47 76.59,138.48 76.72,138.61 v1(76.97,138.61)
PWR_VCCSA_BST: length 4.7
  TOP w0.508: v1(95.58,137.8) 96.62,137.8 PR5001.2 96.69,137.73 96.69,135.6 96.4,135.31 v2(96.02,135.31)
  BOTTOM w0.305: v2(96.02,135.31) 96.12,135.41 PU5001.2
PWR_VCCSA_BST_RC: length 2.3
  TOP w0.508: v1(98.99,139.09) PC5005.1 97.87,139.07 PR5001.1
PWR_VCCSA_COMP: length 8.8
  TOP w0.254: v1(71.48,147.93) v2(72.04,147.73) ; PC4624.1 76.43,149.1 76.43,148.94 75.99,148.49 75.67,148.49 v2(75.34,148.16)
  L5 w0.254: v2(72.04,147.73) 74.91,147.73 v2(75.34,148.16)
  BOTTOM w0.203: v2(75.34,148.16) 76.17,148.16 76.36,148.35 PU4601.24
  BOTTOM w0.254: PR4640.1 71.83,147.52 v2(72.04,147.73)
PWR_VCCSA_COMP_RC: length 1.7
  BOTTOM w0.254: v1(71.25,149.25) PR4640.2 71.22,148.29 PC4601.1
PWR_VCCSA_DRVH: length 6.1
  TOP w0.305: v4(92,134.38) v1(91.27,134.38)
  L3 w0.762: v4(96.5,134.28) 92.11,134.28 v4(92,134.38)
  BOTTOM w0.406: v4(92,134.38) PU5002.4
PWR_VCCSA_DRVL: length 9.2
  TOP w0.305: v4(91.5,137.42) v1(91.29,136.7)
  L3 w0.762: v4(99.11,137.11) 98.8,137.42 v4(91.5,137.42)
  BOTTOM w0.406: v4(91.5,137.42) PU5003.4
PWR_VCCSA_FB: length 6.8
  TOP w0.254: PR4638.2 72.65,146.41 73,146.76 73.65,146.76 PR4632.2 74.45,147.64 74.45,148.36 PR4637.1 74.48,148.45 74.86,148.82 v2(75.24,148.82)
  BOTTOM w0.203: 76.43,148.75 PU4601.25
  BOTTOM w0.254: 76.43,148.75 76.24,148.75 76.09,148.59 v1(75.82,148.59) 75.63,148.59 75.4,148.82 v2(75.24,148.82)
PWR_VCCSA_FB1: length 1.7
  TOP w0.254: PC4621.2 72.7,144.68 PR4638.1 v1(71.76,144.73)
PWR_VCCSA_FB2: length 4.8
  TOP w0.254: PC4616.2 73.62,149.4 PR4637.2 72.85,148.39 PC4617.2 72.72,149.29 PR4601.1 72.07,149.3 PC4620.1 71.51,149.22 v1(71,149.73)
PWR_VCCSA_FB_RC: length 1.8
  TOP w0.254: v1(72.14,146.91) 72.72,147.49 PC4617.1 PR4632.1
PWR_VCCSA_FCCM: length 36.8
  TOP w0.254: v2(75.19,151.17) 75.07,151.28 v1(74.6,151.28)
  L6 w0.254: v2(75.19,151.17) 75.19,151.19 75.74,151.74 80.88,151.74 81.82,150.8 81.82,148.62 82.55,147.88 85.95,147.88 86.33,147.51 86.73,147.51 88.37,145.86 88.37,145.73 89.95,144.15 90.5,144.15 96.02,138.63 96.02,137.75 96.52,137.24 96.99,137.24 v2(99.31,134.93)
  BOTTOM w0.203: 75.92,150.52 76.08,150.37 76.32,150.37 76.34,150.35 PU4601.29
  BOTTOM w0.254: v2(99.31,134.93) 99.31,135.04 99.18,135.17 99.18,135.17 99.03,135.32 99.03,135.32 98.93,135.41 PU5001.7 ; 75.92,150.52 75.27,151.17 v2(75.19,151.17)
PWR_VCCSA_IMON: length 4.1
  TOP w0.254: PC4629.2 77.02,148.67 77.02,148.11 PR4644.1 76.13,147.98 v1(76,147.85) 75.8,147.65 75.62,147.65 v2(75.49,147.52)
  BOTTOM w0.203: PU4601.23 76.43,147.95 76.11,147.63 75.59,147.63 v2(75.49,147.52)
PWR_VCCSA_ISUMN: length 72.1
  TOP w0.254: AFTP4605.1 v2(97.31,131.85) ; PR5004.2 92.71,151.23 92.29,150.8 v2(92.29,150.7)
  L3 w0.254: v2(92.29,150.7) 92.24,150.75 92.24,150.9 91.58,151.56 90.73,151.56 90.54,151.37 89.07,151.37 88.88,151.56 85.42,151.56 85.09,151.89 78.03,151.89 76.53,150.39 75.68,150.39 75.25,149.96 72.23,149.96 71.57,149.3 v2(70.51,149.3)
  L6 w0.254: v2(70.51,149.3) 70.84,148.97 73.53,148.97 74.39,149.84 75.18,149.84 75.5,150.16 76.62,150.16 77.65,149.13 77.65,147.83 78.77,146.71 82.15,146.71 83.19,145.67 84.19,145.67 85.15,144.71 86.46,144.71 88.03,143.13 90.08,143.13 95,138.21 95,135.51 95.89,134.62 95.89,134.02 97.13,132.78 97.13,132.03 v2(97.31,131.85)
  BOTTOM w0.254: v2(70.51,149.3) 70.28,149.53 70.28,150.34 PC4603.2 70.74,150.8 PR4615.1 71.83,150.7 72.49,150.04 PR4620.1 PR4618.2 73.54,149.25 PC4605.1 72.93,148.54 PR4613.1 ; v2(97.31,131.85) 97.16,131.7 PR4611.1
