# Allegro board 17931-1.1228WZS1336.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ57: length 64.7
  L3 w0.089: v2(74.17,86.41) 74.02,86.26 74.02,85.12 71.3,82.4 67.65,82.4 65.27,80.02 65.27,78.93 64.44,78.11 64.44,67.85 64.47,67.82 67.77,64.52 67.77,64.39 67.49,64.11 67.49,63.98 67.62,63.86 67.74,63.86 68.03,64.14 68.15,64.14 68.28,64.01 68.28,63.89 67.99,63.6 67.99,63.48 68.12,63.35 68.24,63.35 68.53,63.64 68.65,63.64 68.78,63.51 68.78,63.38 68.5,63.1 68.5,62.98 68.62,62.85 68.75,62.85 69.03,63.13 69.16,63.13 69.28,63.01 69.28,62.88 69,62.6 69,62.47 69.13,62.35 69.25,62.35 69.53,62.63 69.66,62.63 69.79,62.5 69.79,62.38 69.5,62.1 69.5,61.97 69.63,61.84 69.75,61.84 70.04,62.13 70.16,62.13 70.29,62 70.29,61.88 70,61.59 70,61.47 70.13,61.34 70.26,61.34 70.54,61.62 70.67,61.62 70.79,61.5 70.79,61.37 70.51,61.09 70.51,60.96 70.63,60.84 70.76,60.84 71.04,61.12 71.17,61.12 71.29,61 71.29,60.87 71.01,60.59 71.01,60.46 80.82,50.65 80.82,46.9 80.69,46.77 80.69,46.77 80.44,46.52 80.43,46.52 80.01,46.09 80.01,45.35 80.01,45.35 80.01,45.06 v2(80.04,45.04)
  BOTTOM w0.114: CPU1.L32 74.18,86.41 v2(74.17,86.41) ; DM1.194 80.58,44.5 v2(80.04,45.04)
M_A_DQ58: length 62.8
  L3 w0.089: v2(75.29,89.2) 75.64,88.86 75.64,87.66 75.41,87.43 75.41,86.9 75.06,86.55 75.06,86 75.28,85.78 75.28,84.98 73.92,83.62 73.92,82.93 72.72,81.74 68.18,81.74 65.99,79.55 65.99,78.27 65.37,77.65 65.37,68.32 65.43,68.25 65.43,68.23 75.15,58.51 75.15,57.65 81.75,51.05 81.75,46.52 82.04,46.23 82.04,45.47 82.81,44.71 83.26,44.71 v2(83.57,45.01)
  BOTTOM w0.114: v2(75.29,89.2) 75.69,88.8 CPU1.N29 ; DM1.204 83.08,44.52 v2(83.57,45.01)
M_A_DQ59: length 62.9
  L3 w0.089: v2(75.3,89.84) 75.74,89.39 75.74,89.02 75.83,88.93 75.83,87.58 75.6,87.35 75.6,86.82 75.25,86.47 75.25,86.08 75.47,85.86 75.47,84.84 74.11,83.48 74.11,82.85 72.78,81.52 68.23,81.52 66.21,79.5 66.21,78 65.64,77.43 65.64,68.43 75.42,58.65 75.42,57.76 82.09,51.09 82.09,47.08 82.89,46.28 v2(83.57,46.28)
  BOTTOM w0.114: v2(75.3,89.84) 75.3,89.84 75.37,89.84 75.75,89.46 CPU1.N28 ; v2(83.57,46.28) 84.08,45.77 DM1.208
M_A_DQ60: length 60.8
  L3 w0.089: v2(78.61,46.96) 78.62,46.96 79.08,47.42 79.08,51.23 63.64,66.67 63.64,79.21 67.48,83.05 70.44,83.05 73.31,85.91 73.31,86.72 73.81,87.22 73.81,88.84 73.87,88.9 73.87,89.26 v2(74.36,89.75)
  BOTTOM w0.089: v2(74.36,89.75) 74.53,89.75 CPU1.L28
  BOTTOM w0.114: v2(78.61,46.96) 78.64,46.96 79.52,47.84 79.52,48.52 79.83,48.83 DM1.191
M_A_DQ61: length 62
  L3 w0.089: v2(74.37,89.12) 74.37,89.12 74.37,89.11 74,88.74 74,87.08 73.53,86.61 73.53,85.86 70.5,82.83 67.53,82.83 64.71,80.01 64.71,79.57 63.91,78.77 63.91,66.78 79.35,51.34 79.35,50.65 79.44,50.56 79.75,50.56 79.84,50.47 79.84,50.29 79.75,50.2 79.44,50.2 79.35,50.11 79.35,49.24 79.44,49.15 80.2,49.15 80.29,49.07 80.29,48.89 80.2,48.8 79.44,48.8 79.35,48.71 79.35,46.43 v2(79.15,46.24)
  BOTTOM w0.114: v2(74.37,89.12) 74.38,89.12 74.43,89.06 74.57,89.06 CPU1.L29 ; v2(79.15,46.24) 79.58,45.81 DM1.190
M_A_DQ62: length 63.2
  L3 w0.089: v2(76.25,87.81) 76.25,87.74 75.8,87.29 75.8,86.96 76.05,86.71 76.05,84.68 74.53,83.16 74.53,82.73 72.87,81.08 68.33,81.08 66.77,79.52 66.77,77.59 66.17,76.99 66.17,68.73 79.77,55.14 79.77,55.01 79.41,54.65 79.41,54.53 79.54,54.39 79.67,54.39 80.03,54.75 80.15,54.75 80.29,54.61 80.29,54.49 79.93,54.13 79.93,54 80.07,53.87 80.19,53.87 80.55,54.23 80.68,54.23 80.81,54.09 80.81,53.97 80.45,53.61 80.45,53.48 80.59,53.35 80.71,53.35 81.07,53.71 81.2,53.71 81.33,53.57 81.33,53.45 80.97,53.09 80.97,52.96 81.11,52.83 81.23,52.83 81.59,53.19 81.72,53.19 81.85,53.05 81.85,52.93 81.49,52.57 81.49,52.44 81.63,52.31 81.75,52.31 82.11,52.66 82.24,52.66 82.37,52.53 82.37,52.4 82.02,52.05 82.02,51.92 82.15,51.79 82.28,51.79 82.63,52.14 82.76,52.14 82.95,51.95 v2(82.95,48.66)
  BOTTOM w0.114: DM1.203 82.83,49.24 82.95,49.12 v2(82.95,48.66) ; CPU1.N31 75.92,87.5 76.23,87.81 v2(76.25,87.81)
M_A_DQ63: length 64.8
  L3 w0.089: v2(75.65,86.29) 75.66,86.27 75.66,84.6 74.3,83.24 74.3,82.77 72.83,81.31 68.29,81.31 66.42,79.44 66.42,77.73 65.9,77.21 65.9,68.62 65.92,68.61 66.17,68.36 76.07,58.46 76.07,58.33 75.71,57.97 75.71,57.85 75.85,57.71 75.97,57.71 76.33,58.07 76.45,58.07 76.59,57.94 76.59,57.81 76.23,57.45 76.23,57.33 76.37,57.19 76.49,57.19 76.85,57.55 76.98,57.55 77.11,57.41 77.11,57.29 76.75,56.93 76.75,56.81 76.89,56.67 77.01,56.67 77.37,57.03 77.5,57.03 77.63,56.89 77.63,56.77 77.27,56.41 77.27,56.28 77.41,56.15 77.53,56.15 77.89,56.51 78.02,56.51 78.15,56.37 78.15,56.25 77.79,55.89 77.79,55.76 77.93,55.63 78.06,55.63 78.41,55.99 78.54,55.99 78.67,55.85 78.67,55.73 78.32,55.37 78.32,55.24 78.45,55.11 78.58,55.11 78.94,55.46 79.06,55.46 79.2,55.33 79.2,55.2 78.84,54.85 78.84,54.72 82.43,51.13 82.43,47.54 82.58,47.39 v2(83,47.39)
  BOTTOM w0.114: v2(83,47.39) 83,47.42 83.83,48.24 DM1.207 ; v2(75.65,86.29) 75.65,86.31 CPU1.N32
M_A_DQS_DN0: length 68.8
  L5 w0.102: v2(39.12,45.66) 39.47,45.66 39.72,45.91 39.72,46.39 38.84,47.27 38.84,50.43 57.58,69.18 57.58,78.51 61.83,82.76 61.83,86.68 61.19,87.32 61.19,89.33 61.6,89.74 62.63,89.74 v2(63.19,89.18)
  BOTTOM w0.076: 66.81,90.47 66.83,90.48 66.83,90.52 67.02,90.7 67.13,90.7 67.9,90.7 68.06,90.71 68.29,90.71 68.29,90.71 68.42,90.6 68.72,90.34 69.05,90.34 69.15,90.37 69.35,90.37 69.45,90.34 69.7,90.34 69.8,90.37 70,90.37 70.11,90.33 70.16,90.26 70.2,90.22 70.2,90.17 70.15,90.12 CPU1.C27
  BOTTOM w0.114: DM1.32 38.08,45.31 38.43,45.66 v2(39.12,45.66) ; v2(63.19,89.18) 63.19,89.55 63.63,89.99 64.32,89.99 64.37,90.04 65.3,90.04 65.42,90.16 66.5,90.16 66.81,90.47
M_A_DQS_DN1: length 59.4
  L5 w0.102: v2(65.3,85.14) 65.72,84.91 65.96,84.66 65.96,83.45 65.47,82.95 65.47,81.13 63.94,79.6 63.94,70.08 50.8,56.94 50.8,56.8 51.05,56.55 51.05,56.24 50.79,55.97 50.47,55.97 50.23,56.22 50.08,56.22 49.94,56.08 49.94,55.93 50.19,55.69 50.19,55.38 49.92,55.11 49.61,55.11 49.36,55.36 49.22,55.36 49.08,55.21 49.08,55.07 49.32,54.82 49.32,54.51 49.06,54.25 48.75,54.25 48.68,54.32 48.51,54.32 48.38,54.19 48.38,54.04 48.46,53.96 48.46,53.65 45.32,50.5 45.32,49.35 v2(44.3,48.33)
  BOTTOM w0.076: 66.14,87.16 66.19,87.16 66.22,87.19 66.39,87.19 66.91,87.72 67.53,87.72 67.78,87.97 68.64,87.97 68.64,87.97 68.86,87.97 68.89,88 69.02,88 69.1,88.03 69.11,88.03 69.39,88.03 69.4,88.03 69.48,88 69.67,88 69.75,88.03 69.76,88.03 70.04,88.03 70.05,88.03 70.13,88 70.16,88 70.18,87.98 70.22,87.97 70.28,87.87 70.31,87.85 70.31,87.84 70.38,87.77 CPU1.D31
  BOTTOM w0.114: DM1.53 43.33,48.91 43.76,48.48 44.29,48.32 v2(44.3,48.33) ; v2(65.3,85.14) 65.79,85.63 65.79,86.8 66.14,87.16
M_A_DQS_DN2: length 63.8
  L5 w0.102: v2(49.48,45.77) 50.25,45.77 50.38,45.9 50.38,50.82 65.44,65.88 65.44,66.03 65.26,66.21 65.26,66.53 65.52,66.79 65.83,66.79 66.02,66.6 66.16,66.6 66.31,66.75 66.31,66.89 66.12,67.08 66.12,67.39 66.38,67.65 66.7,67.65 66.88,67.46 67.03,67.46 67.31,67.75 67.31,75.57 68.66,76.91 68.66,80.04 70.01,81.39 70.01,90.56 71.8,92.35 72.62,92.35 72.92,92.06 72.92,91.78 v2(73.13,91.57)
  BOTTOM w0.114: CPU1.H24 v2(73.13,91.57) ; DM1.74 48.58,44.04 48.47,44.15 48.47,45.24 48.85,45.62 49.06,45.62 v2(49.48,45.77)
M_A_DQS_DN3: length 74
  L5 w0.102: v2(34.03,47.95) 33.8,48.18 33.64,48.18 33.36,48.45 33.36,48.69 33.36,50.04 53.92,70.6 53.92,86.92 60.73,93.73 61.98,93.73 62.08,93.83 62.08,94.07 62.3,94.29 62.67,94.29 62.89,94.07 62.89,93.83 63,93.73 63.2,93.73 63.3,93.83 63.3,94.07 63.52,94.29 63.89,94.29 64.11,94.07 64.11,93.83 64.22,93.73 65.76,93.73 v2(66.58,92.9)
  BOTTOM w0.076: 68.1,92.42 68.1,92.42 69.05,92.42 69.15,92.38 69.35,92.38 69.45,92.42 69.7,92.42 69.8,92.38 70,92.38 70.09,92.42 70.11,92.44 70.11,92.57 70.04,92.64 CPU1.C23
  BOTTOM w0.114: DM1.11 32.83,48.42 33.09,48.16 33.82,48.16 v2(34.03,47.95) ; v2(66.58,92.9) 66.44,92.9 66.35,92.82 66.35,92.56 66.49,92.42 68.1,92.42
M_A_DQS_DN4: length 55.2
  L3 w0.089: v2(70.19,79.88) 70.19,79.88 70.32,80 70.32,80.37 70.04,80.65 69.51,80.65 68.99,80.14 68.99,76.74 67.95,75.7 67.95,69.65 85.98,51.61 85.98,47.98 86.11,47.85 86.42,47.85 86.57,48 v2(86.57,48.23)
  BOTTOM w0.076: 72.39,82.12 72.4,82.13 72.44,82.13 72.85,82.55 73.56,82.55 73.84,82.83 73.84,83.98 73.88,84.08 73.88,84.28 73.84,84.38 73.84,84.63 73.88,84.73 73.88,84.93 73.83,85.05 73.81,85.08 73.7,85.08 73.62,85 CPU1.J35
  BOTTOM w0.114: v2(86.57,48.23) 86.57,48 86.7,47.88 86.9,47.88 87.03,47.94 87.1,48.03 87.1,49.97 87,50.07 86.89,50.07 86.83,50.13 DM1.219 ; 72.39,82.12 71.55,81.28 70.98,81.28 70.19,80.5 v2(70.19,79.88)
M_A_DQS_DN5: length 55.8
  L3 w0.089: v2(73.23,77.82) 73.23,77.83 72.85,77.83 72.65,77.62 72.65,74.47 72.09,73.92 72.09,69.76 92.5,49.35 92.5,48.64 92.59,48.55 92.72,48.55 92.92,48.35 92.92,48 92.72,47.8 92.62,47.8 92.54,47.71 92.54,45.66 92.63,45.57 92.96,45.57 v2(93.09,45.7)
  BOTTOM w0.076: 76.09,82.08 76.13,82.12 76.13,82.27 76.65,82.78 76.65,83.31 76.53,83.43 76.53,83.95 76.56,84.02 76.57,84.03 76.57,84.31 76.53,84.41 76.53,84.6 76.57,84.7 76.57,84.91 76.58,84.94 76.53,85.06 76.52,85.12 76.47,85.16 76.43,85.21 76.21,85.21 76.14,85.28 CPU1.P34
  BOTTOM w0.114: v2(73.23,77.82) 74.08,77.82 74.49,78.23 74.49,80.2 75.92,81.63 75.92,81.91 76.09,82.08 ; DM1.240 92.08,43.93 92.2,44.06 92.2,45.16 92.57,45.52 92.91,45.52 v2(93.09,45.7)
M_A_DQS_DN6: length 62.9
  L3 w0.089: v2(75.92,48.06) 76.15,47.83 76.15,47.83 76.15,47.73 76.05,47.63 75.75,47.63 75.71,47.67 75.7,47.67 75.46,47.92 75.46,51.21 70.04,56.63 69.76,56.63 69.49,56.36 69.36,56.36 69.23,56.5 69.23,56.62 69.5,56.89 69.5,57.18 69.25,57.42 68.97,57.42 68.7,57.15 68.57,57.15 68.44,57.29 68.44,57.42 68.71,57.69 68.71,57.97 68.46,58.22 68.05,58.22 67.87,58.04 67.69,58.04 62.01,63.71 62.01,79.98 64.36,82.33 64.36,85.71 64.88,86.22 65.54,86.22 65.84,85.92 68.69,85.92 69.84,87.06 71.46,87.06 71.68,87.28 71.86,87.28 72.21,87.63 72.21,87.71 72.34,87.84 v2(72.55,87.84)
  BOTTOM w0.114: CPU1.G30 72.1,87.92 72.35,87.68 72.44,87.68 72.55,87.79 v2(72.55,87.84) ; v2(75.92,48.06) 75.92,47.8 76.05,47.67 76.23,47.67 76.6,48.04 76.6,49.9 76.33,50.17 DM1.177
M_A_DQS_DN7: length 62.3
  L3 w0.089: v2(81.04,44.97) 80.79,45.22 80.68,45.22 80.42,45.48 80.42,45.93 81.19,46.69 81.19,50.81 74.18,57.81 74.18,58.1 74.39,58.3 74.39,58.43 74.25,58.56 74.12,58.56 73.92,58.36 73.64,58.36 73.39,58.6 73.39,58.89 73.59,59.09 73.59,59.22 73.46,59.35 73.33,59.35 73.13,59.15 72.84,59.15 72.6,59.4 72.6,59.68 72.8,59.88 72.8,60.01 72.6,60.21 72.19,60.21 71.82,60.58 71.82,60.99 64.81,68 64.81,77.84 65.61,78.64 65.61,79.71 68.02,82.12 71.49,82.12 74.29,84.92 74.29,85.78 74.59,86.08 74.59,86.77 74.82,87 74.82,88.01 v2(75.24,88.49)
  BOTTOM w0.114: v2(81.04,44.97) 81.33,44.97 81.58,44.73 DM1.198 ; CPU1.L30 v2(75.24,88.49)
M_A_DQS_DP0: length 68.8
  L5 w0.102: v2(39.12,45.03) 39.92,45.83 39.92,46.48 39.04,47.35 39.04,50.35 57.79,69.09 57.79,78.43 62.04,82.68 62.04,86.76 61.39,87.41 61.39,89.25 61.68,89.54 62.36,89.54 62.49,89.41 v2(62.49,89.18)
  BOTTOM w0.076: 66.65,90.63 66.67,90.64 66.7,90.64 66.94,90.88 67.13,90.88 67.89,90.88 68.05,90.89 68.35,90.89 68.41,90.84 68.79,90.52 69.02,90.52 69.1,90.55 69.11,90.55 69.39,90.55 69.4,90.55 69.48,90.52 69.67,90.52 69.75,90.55 69.76,90.55 70.04,90.55 70.05,90.55 70.13,90.52 70.16,90.52 70.18,90.5 70.22,90.48 70.28,90.39 70.31,90.36 70.31,90.36 70.38,90.29 CPU1.D27
  BOTTOM w0.114: 66.65,90.63 66.41,90.38 65.32,90.38 65.21,90.27 64.28,90.27 64.23,90.22 63.54,90.22 v2(62.49,89.18) ; v2(39.12,45.03) 38.71,45.43 38.52,45.43 38.3,45.22 38.3,44.13 38.58,43.86 DM1.34
M_A_DQS_DP1: length 59.4
  L5 w0.102: v2(44.12,49.06) 44.12,48.86 44.22,48.76 44.44,48.76 45.11,49.44 45.11,50.59 48.26,53.73 48.26,53.88 48.18,53.96 48.18,54.27 48.43,54.52 48.76,54.52 48.83,54.45 48.98,54.45 49.12,54.6 49.12,54.74 48.87,54.99 48.87,55.3 49.14,55.56 49.45,55.56 49.7,55.31 49.84,55.31 49.98,55.46 49.98,55.6 49.74,55.85 49.74,56.16 50,56.42 50.31,56.42 50.56,56.18 50.7,56.18 50.85,56.32 50.85,56.47 50.6,56.71 50.6,57.02 63.74,70.16 63.74,79.69 65.26,81.21 65.26,83.03 65.76,83.53 65.76,84.58 65.63,84.7 65.43,84.7 65.31,84.58 v2(65.31,84.42)
  BOTTOM w0.076: 66.3,87 66.45,87 66.99,87.54 67.61,87.54 67.86,87.79 68.93,87.79 68.97,87.82 69.05,87.82 69.15,87.86 69.35,87.86 69.45,87.82 69.7,87.82 69.8,87.86 70,87.86 70.11,87.82 70.16,87.74 70.2,87.7 70.2,87.65 70.15,87.6 CPU1.C31
  BOTTOM w0.114: v2(44.12,49.06) 44.12,48.83 44.01,48.72 43.84,48.72 43.55,49.01 43.55,50.01 43.62,50.08 43.72,50.08 43.83,50.18 DM1.55 ; v2(65.31,84.42) 65.31,84.57 65.71,84.97 65.71,85.23 66.02,85.54 66.02,86.71 66.3,87
M_A_DQS_DP2: length 63.8
  L5 w0.102: v2(49.3,45.04) 49.59,45.34 49.66,45.34 49.88,45.56 50.33,45.56 50.58,45.81 50.58,50.73 65.65,65.8 65.65,66.11 65.46,66.3 65.46,66.44 65.6,66.59 65.75,66.59 65.94,66.4 66.25,66.4 66.51,66.66 66.51,66.97 66.32,67.16 66.32,67.3 66.47,67.45 66.61,67.45 66.8,67.26 67.11,67.26 67.52,67.67 67.52,75.48 68.86,76.83 68.86,79.96 70.21,81.31 70.21,90.48 71.88,92.15 72.54,92.15 72.71,91.98 72.71,91.79 v2(72.49,91.57)
  BOTTOM w0.114: v2(49.3,45.04) 49.3,45.27 49.17,45.39 48.95,45.39 48.69,45.14 48.69,44.25 49.08,43.87 DM1.76 ; v2(72.49,91.57) 72.49,91.86 72.36,91.99 CPU1.G24
M_A_DQS_DP3: length 74.1
  L5 w0.102: v2(65.94,92.91) 65.94,93.26 65.67,93.52 64.13,93.52 63.91,93.74 63.91,93.98 63.81,94.08 63.61,94.08 63.5,93.98 63.5,93.74 63.28,93.52 62.91,93.52 62.69,93.74 62.69,93.98 62.59,94.08 62.39,94.08 62.29,93.98 62.29,93.74 62.06,93.52 60.81,93.52 54.12,86.83 54.12,70.52 33.57,49.96 33.57,48.6 33.56,48.54 33.72,48.38 34.22,48.38 34.32,48.48 34.32,48.63 v2(34.1,48.84)
  BOTTOM w0.076: CPU1.D23 70.55,92.62 70.28,92.35 70.22,92.29 70.19,92.26 70.03,92.2 69.77,92.2 69.67,92.24 69.48,92.24 69.38,92.2 69.12,92.2 69.09,92.21 69.02,92.24 68.26,92.24 68.22,92.2 68.1,92.2 68.1,92.19
  BOTTOM w0.114: v2(34.1,48.84) 34.1,48.5 33.99,48.39 33.18,48.39 33.05,48.52 33.05,49.87 33.33,50.14 DM1.13 ; 68.1,92.19 66.39,92.19 65.94,92.64 v2(65.94,92.91)
M_A_DQS_DP4: length 55.2
  L3 w0.089: v2(86.57,47.45) 86.36,47.66 86.03,47.66 85.79,47.9 85.79,51.53 67.76,69.57 67.76,75.78 68.8,76.82 68.8,80.22 69.43,80.84 70.11,80.84 70.51,80.45 70.51,80.45 v2(70.72,80.24)
  BOTTOM w0.076: 72.55,81.96 72.56,81.97 72.56,82.01 72.92,82.37 73.63,82.37 74.02,82.76 74.02,83.95 74.04,84.02 74.05,84.03 74.05,84.31 74.02,84.41 74.02,84.6 74.05,84.7 74.05,84.96 73.99,85.15 73.93,85.21 CPU1.J34
  BOTTOM w0.114: 72.55,81.96 71.64,81.05 71.07,81.05 70.72,80.7 v2(70.72,80.24) ; DM1.221 87.33,51.1 87.33,47.95 87.15,47.73 v2(86.57,47.45)
M_A_DQS_DP5: length 55.8
  L3 w0.089: v2(93.09,45.07) 92.78,45.38 92.55,45.38 92.34,45.58 92.34,47.79 92.55,47.99 92.64,47.99 92.73,48.08 92.73,48.27 92.64,48.36 92.51,48.36 92.31,48.56 92.31,49.27 71.9,69.68 71.9,73.99 72.46,74.55 72.46,77.7 72.72,77.96 v2(73.23,78.48)
  BOTTOM w0.076: CPU1.P35 76.14,84.97 76.19,85.03 76.35,85.03 76.36,85.02 76.37,85 76.39,84.93 76.39,84.93 76.39,84.73 76.36,84.63 76.36,84.38 76.39,84.28 76.39,84.08 76.36,83.98 76.36,83.35 76.47,83.24 76.47,82.86 75.93,82.32 75.93,82.25
  BOTTOM w0.114: v2(73.23,78.48) 73.65,78.05 73.99,78.05 74.26,78.32 74.26,80.29 75.69,81.72 75.69,82 75.93,82.25 ; DM1.242 92.58,43.93 92.43,44.07 92.43,45.06 92.66,45.29 92.87,45.29 v2(93.09,45.07)
M_A_DQS_DP6: length 62.9
  L3 w0.089: v2(72.49,88.48) 72.02,87.81 72.02,87.71 71.78,87.48 71.6,87.48 71.38,87.25 69.76,87.25 68.62,86.11 65.92,86.11 65.62,86.41 64.8,86.41 64.17,85.78 64.17,82.41 61.82,80.06 61.82,63.63 67.61,57.85 67.95,57.85 68.13,58.03 68.38,58.03 68.51,57.89 68.51,57.76 68.24,57.49 68.24,57.21 68.49,56.96 68.78,56.96 69.05,57.23 69.17,57.23 69.31,57.1 69.31,56.97 69.04,56.7 69.04,56.42 69.28,56.17 69.57,56.17 69.84,56.44 69.96,56.44 75.27,51.14 75.27,47.84 v2(75.93,47.18)
  BOTTOM w0.114: CPU1.H30 v2(72.49,88.48) ; DM1.179 76.83,47.94 76.2,47.32 v2(75.93,47.18)
M_A_DQS_DP7: length 62.4
  L3 w0.089: v2(81.11,45.66) 80.85,45.41 80.76,45.41 80.61,45.56 80.61,45.85 81.38,46.61 81.38,50.88 74.37,57.89 74.37,58.02 74.58,58.22 74.58,58.51 74.33,58.75 74.05,58.75 73.84,58.55 73.71,58.55 73.58,58.68 73.58,58.81 73.78,59.01 73.78,59.3 73.54,59.54 73.25,59.54 73.05,59.34 72.92,59.34 72.79,59.47 72.79,59.6 72.99,59.8 72.99,60.09 72.68,60.4 72.27,60.4 72.01,60.66 72.01,61.07 65,68.08 65,77.76 65.8,78.56 65.8,79.63 68.1,81.93 71.57,81.93 74.48,84.84 74.48,85.7 74.78,86 74.78,86.69 75.01,86.92 75.01,87.6 v2(75.23,87.82)
  BOTTOM w0.114: CPU1.N30 75.81,88.04 75.78,87.88 75.55,87.74 v2(75.23,87.82) ; DM1.200 82.08,43.79 81.95,43.92 81.88,43.92 81.8,43.99 81.8,44.82 81.48,45.15 81.11,45.52 v2(81.11,45.66)
M_A_PARITY: length 51.1
  L5 w0.14: v2(66.88,49.66) 67.39,49.66 81.23,63.5 81.23,80.06 81.63,80.46 81.63,81.25 81.15,81.74 80.81,81.74 77.88,84.67 77.88,85.75 77.4,86.23 77.4,86.81 77.52,86.93 77.52,87.34 77.6,87.42 77.6,87.94 77.89,88.23 78.6,88.23 v2(78.94,87.89)
  BOTTOM w0.14: v2(66.88,49.66) 66.8,49.58 66.6,49.58 65.83,50.36 DM1.143 ; CPU1.W31 v2(78.94,87.89)
M_B_A0: length 90.6
  L3 w0.114: v2(84.87,79.94) 85.25,79.57 85.25,73.12 96.22,62.15 100.01,62.15 102.28,59.88 102.28,59.08 104.77,56.59 138.63,56.59 141.91,53.31 141.91,52.74 143.03,51.61 143.03,45.99 v2(144.31,44.72)
  BOTTOM w0.076: v2(84.87,79.94) 84.87,79.94 84.45,80.36 84.45,82.75 84.43,82.76 84.43,82.77 84.39,82.81 84.39,83.5 84.59,83.71 84.59,83.98 84.34,84.45 CPU1.AG36
  BOTTOM w0.14: DM2.144 142.28,44.48 142.6,44.81 143.74,44.81 143.83,44.72 v2(144.31,44.72)
M_B_A1: length 91.8
  L3 w0.114: v2(83.47,78.82) 83.47,78.96 83.06,79.38 82.86,79.38 82.72,79.24 82.72,78.31 82.91,78.12 82.91,76.92 83.05,76.77 83.36,76.77 83.48,76.64 83.48,76.31 83.35,76.18 82.48,76.18 82.37,76.07 82.37,75.86 82.5,75.72 83.34,75.72 83.45,75.61 83.45,75.38 83.34,75.27 82.48,75.27 82.36,75.15 82.36,74.94 82.49,74.81 83.35,74.81 83.46,74.7 83.46,74.47 83.34,74.35 82.48,74.35 82.36,74.23 82.36,74.02 82.49,73.9 83.35,73.9 83.46,73.78 83.46,73.57 83.33,73.44 83.02,73.44 82.88,73.29 82.88,73.12 82.99,73.01 83.23,73.01 83.36,72.88 83.36,72.59 95.51,60.43 98.5,60.43 104.09,54.84 127.36,54.84 127.54,54.66 128.2,54.66 128.41,54.87 128.66,54.87 128.87,54.66 129.11,54.66 129.33,54.87 129.57,54.87 129.79,54.66 130.03,54.66 130.24,54.87 130.49,54.87 130.7,54.66 130.94,54.66 131.16,54.87 131.4,54.87 131.61,54.66 131.86,54.66 132.07,54.87 132.31,54.87 132.53,54.66 132.77,54.66 132.99,54.87 133.23,54.87 133.44,54.66 133.69,54.66 133.9,54.87 134.14,54.87 134.36,54.66 134.6,54.66 134.81,54.87 135.06,54.87 135.27,54.66 135.52,54.66 135.73,54.87 135.97,54.87 136.19,54.66 136.43,54.66 136.64,54.87 136.89,54.87 137.1,54.66 137.34,54.66 137.56,54.87 137.92,54.87 138.28,54.52 138.28,54.36 137.99,54.07 137.99,53.91 138.14,53.76 138.31,53.76 138.58,54.03 138.76,54.03 138.92,53.87 138.92,53.71 138.88,53.67 138.88,53.48 139.02,53.34 139.2,53.34 139.24,53.38 139.42,53.38 139.75,53.05 139.75,52.8 v2(139.65,52.71)
  BOTTOM w0.076: 84.06,79.01 84.08,79.03 84.08,82.64 84.03,82.69 84.03,83.82 84.11,84.03 84.11,84.33 84.09,84.39 84.09,84.62 84.25,85.06 CPU1.AG35
  BOTTOM w0.14: 84.06,79.01 84.06,78.8 84.05,78.8 84.05,78.74 83.93,78.62 83.66,78.62 v2(83.47,78.82) ; DM2.133 139.53,52.58 v2(139.65,52.71)
M_B_A2: length 93.2
  L3 w0.114: v2(83.46,79.55) 83.75,79.55 83.88,79.43 83.88,77.85 83.75,77.73 83.28,77.73 83.15,77.6 83.15,77.11 83.28,76.99 83.57,76.99 83.7,76.86 83.7,72.73 95.65,60.78 98.64,60.78 104.2,55.22 138.06,55.22 140.5,52.78 140.5,52.31 140.39,52.2 139.96,52.2 139.85,52.09 139.85,51.86 139.96,51.74 140.39,51.74 140.5,51.63 140.5,51.29 140.39,51.17 140.2,51.17 140.09,51.06 140.09,50.83 140.2,50.71 140.39,50.71 140.5,50.6 140.5,50.22 140.38,50.1 139.84,50.1 139.59,49.84 139.59,48.96 139.44,48.81 138.69,48.81 v2(138.5,49)
  BOTTOM w0.076: 83.87,80.08 83.87,82.6 83.87,82.6 83.87,83.85 83.94,84.06 83.94,84.3 83.92,84.36 83.92,84.65 83.94,84.71 83.94,85.23 CPU1.AF34
  BOTTOM w0.14: v2(138.5,49) 138.5,48.27 138.92,46.32 138.92,46.3 139.21,45.69 139.28,45.27 139.28,42.91 DM2.132 ; v2(83.46,79.55) 83.74,79.55 83.87,79.68 83.87,80.08
M_B_A3: length 92.1
  L3 w0.114: v2(84.32,78.07) 84.32,77.41 84.04,77.13 84.04,72.87 95.79,61.12 98.78,61.12 104.34,55.56 138.21,55.56 140.85,52.92 140.85,52.63 140.85,51.5 141.39,50.96 141.39,50.6 141.28,50.48 140.96,50.48 140.85,50.37 140.85,50.14 140.96,50.03 141.28,50.03 141.39,49.91 141.39,49.57 141.28,49.45 140.59,49.45 140.47,49.34 140.47,49.11 140.59,49 141.28,49 141.39,48.88 141.39,48.65 141.28,48.54 140.59,48.54 140.47,48.42 140.47,48.2 140.59,48.08 141.28,48.08 141.39,47.97 141.39,47.52 v2(141.27,47.4)
  BOTTOM w0.076: CPU1.AG37 84.2,83.71 84.2,82.76 84.28,82.68 84.28,79.78
  BOTTOM w0.127: 84.28,79.78 84.28,78.7
  BOTTOM w0.14: 84.28,78.7 84.28,78.11 v2(84.32,78.07) ; DM2.131 139.03,47.59 139.49,47.12 140.18,47.12 140.48,47.43 141.24,47.43 v2(141.27,47.4)
M_B_A4: length 92.6
  L3 w0.114: v2(83.47,80.92) 84.11,80.29 84.11,78.93 84.76,78.28 84.76,77.04 84.39,76.67 84.39,73.01 95.94,61.46 98.66,61.46 98.93,61.46 104.49,55.9 138.35,55.9 141.22,53.03 141.22,52.56 141.26,52.38 141.73,51.9 141.73,46.48 141.12,45.86 138.97,45.86 138.82,46.02 v2(137.89,46.02)
  BOTTOM w0.076: v2(83.47,80.92) 83.47,80.97 82.92,81.52 82.92,82.45 83.31,82.85 83.31,83.91 83.27,84.03 83.27,84.33 83.3,84.41 83.3,84.9 CPU1.AE35
  BOTTOM w0.14: v2(137.89,46.02) 138.28,45.64 DM2.128
M_B_A5: length 91.3
  L3 w0.114: v2(83.42,81.58) 84.39,80.62 84.39,79.09 84.97,78.51 84.97,76.6 84.9,76.54 84.9,72.98 96.08,61.8 98.81,61.8 99.07,61.8 104.63,56.24 138.49,56.24 141.56,53.17 141.56,52.6 141.57,52.55 142.08,52.05 142.08,46.33 141.26,45.52 139.72,45.52 138.97,44.99 v2(137.82,44.5)
  BOTTOM w0.076: v2(83.42,81.58) 83.08,81.92 83.08,82.38 83.48,82.78 83.48,83.94 83.44,84.06 83.44,84.3 83.59,84.73 CPU1.AF35
  BOTTOM w0.14: DM2.126 137.78,44.46 v2(137.82,44.5)
M_B_A6: length 92.9
  L3 w0.114: v2(82.48,77.36) 82.24,77.36 82.12,77.23 82.12,73.34 95.37,60.09 98.36,60.09 103.95,54.5 127.22,54.5 127.4,54.32 136.5,54.32 136.61,54.2 136.61,53.74 136.73,53.63 136.89,53.63 137.01,53.74 137.01,54.2 137.12,54.32 137.47,54.32 137.61,54.18 v2(137.61,53.2)
  BOTTOM w0.076: CPU1.AE37 83.15,83.74 83.15,82.92 82.75,82.52 82.75,81.45 83.02,81.19 83.02,80.87
  BOTTOM w0.14: v2(137.61,53.2) 138.03,52.78 DM2.127 ; v2(82.48,77.36) 81.82,76.7 81.82,75.19 82.03,74.98 82.45,74.98 82.59,75.12 82.59,76.11 82.73,76.25 83.01,76.25 83.15,76.11 83.15,75.12 83.29,74.98 83.57,74.98 83.71,75.12 83.71,76.35 83.84,76.49 84.12,76.49 84.27,76.34 84.27,75.12 84.41,74.98 84.77,74.98 84.9,75.11 84.9,76.78 84.13,77.55 83.47,77.55 83.02,78 83.02,80.87
M_B_A7: length 90.3
  L3 w0.114: v2(136.78,44.39) 136.47,44.39 136.01,44.84 136.01,46.83 133.17,49.68 131.66,49.68 131.44,49.9 131.44,50.26 131.31,50.39 131.05,50.39 130.95,50.28 130.95,50.11 130.83,50 130.56,50 130.45,50.11 130.45,50.27 130.34,50.39 126.38,50.39 123.9,51.36 123.18,51.61 102.72,51.61 100.14,54.2 93.92,57.33 93.86,57.33 79.04,72.15 79.04,73.86 78.84,74.06 78.84,82.76 81.25,85.17 81.25,85.57 82.1,86.42 82.1,88.14 v2(81.68,88.56)
  BOTTOM w0.14: DM2.122 v2(136.78,44.39) ; v2(81.68,88.56) 81.88,88.56 CPU1.AC29
M_B_A8: length 90.6
  L3 w0.114: v2(136.88,53.19) 136.58,52.89 136.58,52.63 136.96,52.25 137.2,52.25 137.7,52.76 137.88,52.76 138.07,52.58 138.07,52.41 137.51,51.86 137.51,51.7 137.63,51.58 137.79,51.58 138.34,52.14 138.51,52.14 138.62,52.02 138.62,51.86 138.07,51.3 138.07,51.14 138.18,51.02 138.35,51.02 138.9,51.58 139.06,51.58 139.4,51.24 139.4,50.86 139.06,50.52 138.03,50.52 135.96,52.58 135.96,52.89 135.96,52.89 135.96,53.18 135.17,53.97 127.26,53.97 127.08,54.15 103.81,54.15 98.21,59.75 95.23,59.75 81.77,73.2 81.77,77.87 81.95,78.04 v2(82.34,78.04)
  BOTTOM w0.076: 82.76,81.02 82.59,81.19 82.59,82.61 82.97,83 82.97,83.5 82.78,83.69 82.78,83.98 82.89,84.18 82.89,84.19 83.04,84.46 CPU1.AE36
  BOTTOM w0.14: DM2.125 137.53,52.55 v2(136.88,53.19) ; 82.76,81.02 82.76,78.46 v2(82.34,78.04)
M_B_A9: length 89
  L3 w0.114: v2(80.75,89.16) 81.11,88.8 81.19,88.45 81.19,86.39 78.62,82.89 78.62,72.64 78.71,71.9 93.47,57.14 100,53.85 102.58,51.27 122.89,51.27 123.93,50.91 124.06,50.87 124.06,50.86 125.65,50.31 126.32,50.04 128.77,50.04 133.19,48.88 133.57,48.64 v2(135.28,46.92)
  BOTTOM w0.14: CPU1.AB29 v2(80.75,89.16) ; DM2.121 136.53,49.65 135.89,47.87 v2(135.28,46.92)
M_B_A10: length 92.2
  L3 w0.114: v2(84.91,82.5) 85.68,81.73 85.68,73.92 85.93,73.67 85.93,73.41 96.51,62.83 100.29,62.83 103.55,59.57 103.55,59.41 103.32,59.17 103.32,59.01 103.48,58.85 103.64,58.85 103.88,59.09 104.04,59.09 104.21,58.93 104.21,58.77 103.96,58.53 103.96,58.37 104.13,58.2 104.29,58.2 104.53,58.45 104.69,58.45 104.85,58.28 104.85,58.12 104.61,57.88 104.61,57.72 104.77,57.56 104.93,57.56 105.18,57.8 105.34,57.8 105.86,57.27 138.92,57.27 142.59,53.6 142.59,53.02 143.89,51.73 143.89,47.45 v2(144.17,47.17)
  BOTTOM w0.076: CPU1.AG34 84.34,85.58 84.64,85.28 84.64,84.24 84.76,84.02 84.76,83.62 84.55,83.42 84.55,82.88 84.91,82.52 v2(84.91,82.5)
  BOTTOM w0.14: DM2.146 144.78,45.69 v2(144.17,47.17)
M_B_A11: length 92.7
  L3 w0.114: v2(136.88,45.66) 136.43,46.1 136.43,49.45 135.51,50.37 135.35,50.37 135,50.03 134.84,50.03 134.68,50.18 134.68,50.36 135.01,50.69 135.01,50.87 134.81,51.07 127.05,51.07 125.94,52.18 125.92,52.18 125.8,52.3 103.02,52.3 100.55,54.76 94.21,57.95 79.73,72.42 79.73,74.21 79.28,74.65 79.28,81.55 82.01,84.27 82.01,85.7 82.58,86.28 v2(82.58,89.13)
  BOTTOM w0.14: v2(136.88,45.66) 136.78,45.66 136.33,45.21 136.33,44.53 136.32,44.52 136.32,44.04 136.27,43.99 136.27,42.91 DM2.120 ; CPU1.AC28 v2(82.58,89.13)
M_B_A12: length 90.4
  L3 w0.114: v2(135.57,48.9) 135.36,48.9 135.25,48.79 135.25,48.59 135.09,48.43 134.9,48.43 133.26,50.07 132.96,50.07 132.83,50.2 132.83,50.58 132.71,50.71 132.42,50.71 132.31,50.59 132.31,50.16 132.19,50.04 131.92,50.04 131.78,50.17 131.78,50.61 131.67,50.73 126.89,50.73 125.66,51.96 125.32,51.96 125.2,51.84 125.2,51.62 125.09,51.51 124.86,51.51 124.75,51.62 124.75,51.83 124.62,51.96 102.87,51.96 100.49,54.33 100.34,54.48 94,57.67 79.38,72.29 79.38,74.07 79.05,74.39 79.05,81.66 81.68,84.29 81.68,85.7 82.32,86.33 82.32,88.5 81.03,89.79 v2(80.8,89.79)
  BOTTOM w0.14: DM2.119 136.03,49.87 136.05,49.85 136.05,49.37 v2(135.57,48.9) ; CPU1.AB28 v2(80.8,89.79)
M_B_A13: length 92.4
  L3 w0.114: v2(148.34,45.18) 149.15,45.18 149.37,45.4 149.37,51.51 140.53,60.36 107.9,60.36 100.75,67.5 96.6,67.5 v2(88.05,76.05)
  BOTTOM w0.076: 85.88,79.78 85.88,79.88 86.07,80.07 86.48,80.07 86.76,80.36 86.76,82.54 86.48,82.82 86.48,84.28 86.46,84.33 86.44,84.35 86.44,84.52 86.4,84.64 CPU1.AK35
  BOTTOM w0.14: 85.88,79.78 85.88,77.14 86.97,76.05 v2(88.05,76.05) ; DM2.158 147.78,44.62 v2(148.34,45.18)
M_B_A14: length 91.1
  L3 w0.114: v2(146.56,49.67) 146.56,52.39 139.96,58.99 106.57,58.99 101.1,64.46 101.1,64.8 100.79,65.12 100.4,65.12 100.28,65.25 100.28,66.01 100.16,66.12 99.94,66.12 99.82,66.01 99.82,65.26 99.71,65.14 99.48,65.14 99.36,65.26 99.36,66.01 99.25,66.12 99.02,66.12 98.91,66.01 98.91,65.26 98.79,65.14 98.56,65.14 98.45,65.26 98.45,66.01 98.33,66.12 98.11,66.12 97.99,66.01 97.99,65.26 97.88,65.14 97.65,65.14 97.53,65.26 97.53,66.01 97.42,66.12 97.19,66.12 97.08,66.01 97.08,65.26 96.96,65.14 96.62,65.14 87.39,74.38 87.39,80.06 v2(86.34,81.1)
  BOTTOM w0.076: v2(86.34,81.1) 85.8,81.64 85.8,82.82 85.88,82.9 85.88,83.77 85.79,84.03 85.79,84.33 85.81,84.39 85.81,84.62 85.78,84.71 85.78,84.72 85.65,85.06 CPU1.AJ35
  BOTTOM w0.14: v2(146.56,49.67) 146.03,50.2 DM2.151
M_B_A15: length 92.8
  L3 w0.114: v2(86.36,81.74) 85.9,81.27 85.9,74.01 86.3,73.61 86.3,73.52 96.65,63.18 100.44,63.18 106.01,57.62 139.06,57.62 142.94,53.74 142.94,53.16 144.61,51.49 144.61,51.01 144.5,50.9 144.43,50.9 144.31,50.78 144.31,50.56 144.43,50.44 144.5,50.44 144.61,50.33 144.61,50.1 144.5,49.98 144.43,49.98 144.31,49.87 144.31,49.64 144.43,49.53 144.5,49.53 144.61,49.41 144.61,49.18 144.5,49.07 144.43,49.07 144.31,48.96 144.31,48.73 144.43,48.61 144.5,48.61 144.61,48.5 144.61,48.27 144.5,48.16 144.43,48.16 144.31,48.04 144.31,47.81 144.43,47.7 144.5,47.7 144.61,47.58 144.61,46.82 144.79,46.64 145.49,46.64 145.64,46.54 145.76,46.18 145.76,45.12 145.89,45 146.41,45 v2(146.76,45.34)
  BOTTOM w0.076: CPU1.AK34 85.95,85.23 85.95,84.71 85.97,84.65 85.97,84.36 85.95,84.3 85.95,84.06 86.05,83.8 86.05,82.83 85.97,82.75 85.97,82.46 85.97,82.46 85.97,82.13 v2(86.36,81.74)
  BOTTOM w0.14: v2(146.76,45.34) 147.28,44.82 DM2.156
M_B_A16: length 91.6
  L3 w0.114: v2(84.85,81.23) 85.47,80.61 85.47,73.83 85.59,73.71 85.59,73.27 96.36,62.49 100.15,62.49 102.62,60.02 102.62,59.22 104.83,57.02 104.92,56.93 138.78,56.93 142.25,53.46 142.25,52.88 143.45,51.68 143.45,46.43 144.27,45.6 v2(145.32,45.6)
  BOTTOM w0.076: v2(84.85,81.23) 85.3,81.69 85.3,82.33 85.31,82.34 85.31,82.66 85.3,82.67 85.3,83.02 85.34,83.06 85.34,83.43 85.14,83.64 85.14,84.03 85.15,84.05 85.19,84.13 85.26,84.24 85.26,85.19 85.55,85.8 CPU1.AJ34
  BOTTOM w0.14: DM2.152 146.28,45.04 145.71,45.6 v2(145.32,45.6)
M_B_ACT_N: length 90.1
  L3 w0.114: v2(133.78,45.63) 132.61,46.23 131.73,46.45 113.85,46.45 112.98,47.32 112.98,47.74 111.84,49.69 111.63,49.9 102.01,49.9 99.2,52.71 92.67,56 91.94,56.73 91.93,56.73 77.28,71.38 77.25,71.51 77.24,71.54 77.2,71.91 76.7,73.98 76.7,84.25 78.48,86.03 78.48,89.33 v2(78.95,89.79)
  BOTTOM w0.14: DM2.114 134.78,44.64 134.25,45.16 134.25,45.17 133.99,45.43 133.98,45.43 v2(133.78,45.63) ; CPU1.W28 v2(78.95,89.79)
M_B_ALERT_N: length 89.2
  L3 w0.114: v2(79.85,88.54) 79.85,86.53 77.2,83.88 77.2,74.34 77.94,73.6 77.94,72.48 77.94,71.8 77.95,71.78 77.95,71.69 93.06,56.58 99.59,53.29 102.3,50.59 122.51,50.59 124.03,50.14 125.27,49.71 125.74,49.24 128.6,49.24 130.47,47.37 134.01,47.37 134.56,46.81 134.56,45.62 135.36,44.83 v2(135.37,44.83)
  BOTTOM w0.14: v2(79.85,88.54) CPU1.Y29 ; v2(135.37,44.83) 135.28,44.73 DM2.116
M_B_BA0: length 93
  L3 w0.114: v2(145.29,44.97) 146.01,44.25 146.93,44.25 147.52,44.84 147.52,45 148.83,46.31 148.83,51.29 148.83,51.57 140.38,60.02 107.75,60.02 100.61,67.16 96.29,67.16 v2(88.06,75.39)
  BOTTOM w0.076: 85.68,81.13 85.68,81.53 85.64,81.57 85.64,82.89 85.71,82.96 85.71,83.7 CPU1.AJ37
  BOTTOM w0.14: 85.68,81.13 85.65,81.1 85.65,77.05 87.31,75.39 v2(88.06,75.39) ; DM2.150 145.78,44.49 v2(145.29,44.97)
M_B_BA1: length 93.8
  L3 w0.114: v2(147.53,46.3) 148.03,46.3 148.49,46.75 148.49,51.43 140.24,59.67 107.61,59.67 100.47,66.82 96.02,66.82 v2(88.08,74.75)
  BOTTOM w0.076: 85.47,81.38 85.47,82.26 85.47,82.27 85.47,82.73 85.47,82.73 85.47,82.95 85.51,82.99 85.51,83.5 85.3,83.71 85.3,83.98 85.33,84.03 85.42,84.2 85.42,84.32 85.47,84.42 CPU1.AJ36
  BOTTOM w0.14: v2(88.08,74.75) 87.2,74.75 85.31,76.64 85.31,81.23 85.47,81.38 ; v2(147.53,46.3) 146.09,46.79 144.77,48.72 144.66,48.9 144.53,49.54 DM2.145
M_B_BG0: length 90.3
  L3 w0.114: v2(78.92,89.16) 79.38,88.69 79.38,86.37 76.92,83.9 76.92,74.07 76.96,73.88 77.59,73.25 77.59,71.65 77.59,71.56 77.64,71.51 92.25,56.9 92.86,56.29 99.39,53.01 102.15,50.24 122.36,50.24 123.89,49.79 124.41,49.65 124.96,49.46 125.16,49.25 126.29,47.24 126.61,46.92 v2(133.84,46.92)
  BOTTOM w0.14: v2(133.84,46.92) 134.63,47.7 135.03,49.05 DM2.115 ; CPU1.W29 v2(78.92,89.16)
M_B_BG1: length 89.8
  L3 w0.114: v2(79.85,89.17) 80.26,88.76 80.26,86.63 78.04,84.41 78.04,83.14 77.61,82.71 77.61,74.49 78.28,73.82 78.28,72.34 78.28,71.88 78.29,71.83 93.26,56.86 99.79,53.57 102.44,50.93 122.69,50.93 123.3,50.75 123.82,50.58 125.46,50.01 125.89,49.58 128.74,49.58 129.3,49.03 129.46,49.03 129.66,49.23 129.82,49.23 129.98,49.07 129.98,48.91 129.78,48.71 129.78,48.54 130.5,47.83 131.96,47.83 132.08,47.94 132.08,48.55 132.19,48.67 132.42,48.67 132.53,48.55 132.53,47.94 132.65,47.83 v2(133.73,47.83)
  BOTTOM w0.14: v2(133.73,47.83) 134.53,48.62 DM2.113 ; v2(79.85,89.17) CPU1.Y28
M_B_CKE0: length 90
  L3 w0.114: v2(78.01,89.14) 77.54,88.67 77.54,86.71 77.4,86.57 77.4,86.17 76.86,85.64 76.86,84.81 76.49,84.44 76.49,73.18 76.71,72.22 76.88,71.55 76.97,71.21 92.84,55.34 92.84,55.34 92.86,55.32 97.9,52.31 103.31,46.91 104.78,45.96 104.99,45.75 104.99,45.57 105.39,45.17 111.15,45.17 127.3,45.83 127.39,45.84 129.4,45.92 v2(131.91,45.92)
  BOTTOM w0.14: v2(131.91,45.92) 132.9,48.89 133.53,49.96 DM2.109 ; v2(78.01,89.14) CPU1.T28
M_B_CKE1: length 88.5
  L3 w0.114: v2(77.14,89.18) 76.67,88.7 76.67,87.13 76.53,86.4 76.33,84.64 75.65,83.21 75.65,83.14 75.65,82.68 76.11,79.31 76.11,73.07 76.66,71 92.67,54.99 97.65,51.97 104.11,45.51 104.11,45.39 104.4,45.1 105.09,44.82 116.12,44.82 127.31,45.49 129.44,45.58 130.47,45.58 131.39,45.5 v2(133.78,44.35)
  BOTTOM w0.14: DM2.110 v2(133.78,44.35) ; CPU1.T29 v2(77.14,89.18)
M_B_CLK0: length 96.1
  L3 w0.089: v2(140.03,49.02) 140.03,48.86 139.6,48.43 138.16,48.43 137.68,48.9 137.68,49.84 135.24,52.28 135.24,52.88 134.87,53.25 130.67,53.25 130.47,53.05 130.47,52.41 130.37,52.31 130.18,52.31 130.1,52.39 130.1,53.05 129.9,53.25 129.55,53.25 129.35,53.05 129.35,52.41 129.25,52.31 129.07,52.31 128.98,52.4 128.98,53.05 128.78,53.25 126.96,53.25 126.78,53.43 103.51,53.43 97.91,59.02 94.91,59.02 80.97,72.96 80.97,79.47 82.16,80.66 82.16,81.63 83.86,83.34 83.86,85.06 84.98,86.18 84.98,87.45 84.55,87.87 84.28,87.87 84.08,88.07 84.08,88.25 84.22,88.47 v2(84.47,88.47)
  BOTTOM w0.114: DM2.137 140.53,50.18 140.62,50.09 140.69,50.09 140.8,49.99 140.8,48.72 140.6,48.52 140.34,48.52 140.03,48.83 v2(140.03,49.02) ; v2(84.47,88.47) 84.46,88.46 84.34,88.35 84.18,88.35 83.95,88.57 CPU1.AF29
M_B_CLK1: length 95.4
  L3 w0.089: v2(140.75,46.98) 140.4,46.64 139.56,46.64 137.9,47.72 137.1,48.48 137.1,49.61 135.05,51.66 127.28,51.66 126.06,52.87 103.28,52.87 97.79,58.36 94.72,58.36 80.31,72.78 80.31,74.35 79.68,74.98 79.68,81.3 83.27,84.89 83.27,85.94 82.98,86.22 82.98,88.42 83.11,88.55 83.21,88.55 v2(83.48,88.55)
  BOTTOM w0.114: CPU1.AE29 83.23,88.8 v2(83.48,88.55) ; v2(140.75,46.98) 140.12,46.35 140.12,45.82 141.05,44.9 141.05,44.07 140.78,43.8 DM2.138
M_B_CLK#0: length 96.1
  L3 w0.089: v2(140.01,48.24) 138.08,48.24 137.49,48.82 137.49,49.76 135.05,52.2 135.05,52.8 134.79,53.06 130.75,53.06 130.66,52.97 130.66,52.33 130.45,52.12 130.1,52.12 129.91,52.31 129.91,52.97 129.82,53.06 129.63,53.06 129.54,52.97 129.54,52.33 129.33,52.12 128.99,52.12 128.79,52.33 128.79,52.97 128.7,53.06 126.88,53.06 126.7,53.24 103.43,53.24 97.84,58.83 94.83,58.83 80.78,72.88 80.78,79.55 81.97,80.74 81.97,81.71 83.67,83.41 83.67,85.14 84.79,86.26 84.79,87.37 84.48,87.68 84.2,87.68 83.89,87.99 83.89,88.3 83.89,88.3 v2(84.37,89.1)
  BOTTOM w0.114: DM2.139 141.03,48.62 140.69,48.29 140.25,48.29 140.24,48.3 v2(140.01,48.24) ; CPU1.AF28 v2(84.37,89.1)
M_B_CLK#1: length 95.4
  L3 w0.089: v2(140.76,46.3) 140.62,46.45 139.5,46.45 137.79,47.57 136.91,48.39 136.91,49.53 134.97,51.47 127.2,51.47 125.98,52.68 103.2,52.68 97.71,58.17 94.64,58.17 80.11,72.7 80.11,74.27 79.49,74.9 79.49,81.38 83.08,84.97 83.08,85.86 82.79,86.15 82.79,88.5 83.48,89.19 v2(83.48,89.19)
  BOTTOM w0.114: CPU1.AE28 v2(83.48,89.19) ; v2(140.76,46.3) 140.48,46.3 140.35,46.18 140.35,45.91 141.28,44.99 DM2.140
M_B_CS#0: length 92.1
  L3 w0.114: v2(86.34,79.68) 86.63,79.97 86.97,79.97 87.14,79.79 87.14,74.14 97.07,64.21 97.44,64.21 97.56,64.32 97.56,64.66 97.67,64.78 97.9,64.78 98.01,64.66 98.01,64.32 98.13,64.21 98.36,64.21 98.47,64.32 98.47,64.66 98.59,64.78 98.81,64.78 98.93,64.66 98.93,64.32 99.04,64.21 99.27,64.21 99.39,64.32 99.39,64.66 99.5,64.78 99.73,64.78 99.84,64.66 99.84,64.32 99.96,64.21 100.19,64.21 100.3,64.32 100.3,64.66 100.41,64.78 100.64,64.78 100.76,64.66 100.76,64.32 106.43,58.64 139.82,58.64 143.96,54.5 143.96,54.21 143.96,53.59 144.63,52.93 144.79,52.93 145.08,53.22 145.24,53.22 145.4,53.06 145.4,52.9 145.11,52.6 145.11,52.44 145.27,52.28 145.44,52.28 145.73,52.57 145.89,52.57 146.05,52.41 146.05,52.25 145.66,51.86 145.66,51.68 146.11,51.23 146.11,48.77 v2(146.48,48.4)
  BOTTOM w0.076: CPU1.AL37 86.64,83.64 86.64,82.9 86.92,82.63 86.92,80.29 86.34,79.7 v2(86.34,79.68)
  BOTTOM w0.14: v2(146.48,48.4) 146.48,48.4 145.53,49.35 DM2.149
M_B_CS#1: length 93.2
  L3 w0.114: v2(147.94,47.58) 147.72,47.58 147.6,47.7 147.6,48.02 147.47,48.14 147.07,48.14 146.94,48.02 146.94,46.96 146.68,46.69 146.37,46.69 146.36,46.69 145.99,46.69 145.93,46.75 145.6,46.99 145.17,46.99 144.96,47.21 144.96,51.63 143.28,53.31 143.28,54.21 139.53,57.96 106.15,57.96 100.59,63.52 96.79,63.52 86.41,73.9 v2(86.41,78.41)
  BOTTOM w0.076: CPU1.AL35 87.18,84.84 87.21,84.77 87.21,84.14 87.22,84.13 87.28,84.03 87.28,83.62 87.04,83.39 87.04,83.38 87.04,83.37 87.04,83 87.28,82.75 87.28,79.38 86.41,78.51 v2(86.41,78.41)
  BOTTOM w0.14: v2(147.94,47.58) 147.53,48 DM2.157
M_B_DIMB_ODT0: length 93.5
  L3 w0.114: v2(86.36,79.04) 86.37,79.04 86.87,78.54 86.87,73.93 96.93,63.86 100.73,63.86 106.12,58.47 106.29,58.3 139.67,58.3 143.62,54.35 143.62,53.45 145.3,51.77 145.3,51.23 145.41,51.11 145.65,51.11 145.77,51 145.77,50.77 145.65,50.66 145.41,50.66 145.3,50.54 145.3,50.31 145.41,50.2 145.65,50.2 145.77,50.08 145.77,49.86 145.65,49.74 145.41,49.74 145.3,49.63 145.3,49.4 145.41,49.28 145.65,49.28 145.77,49.17 145.77,48.94 145.65,48.83 145.41,48.83 145.3,48.71 145.3,48.48 145.41,48.37 145.91,48.37 146.02,48.26 146.02,48.04 145.89,47.91 145.41,47.91 145.3,47.8 145.3,47.46 145.42,47.33 145.71,47.33 145.99,47.13 v2(146.5,47.13)
  BOTTOM w0.076: CPU1.AL36 87.05,84.16 87.05,84.07 87.09,84.03 87.11,83.99 87.11,83.71 86.87,83.47 86.87,82.93 87.12,82.68 87.12,79.89 86.36,79.14 86.36,79.05 v2(86.36,79.04)
  BOTTOM w0.14: DM2.155 147.03,47.81 147.36,47.47 147.36,47.08 147.17,46.88 146.74,46.88 v2(146.5,47.13)
M_B_DIMB_ODT1: length 93.2
  L3 w0.114: v2(86.86,86.32) 86.86,81.42 87.63,80.66 87.63,74.62 95.78,66.47 100.33,66.47 102.3,64.5 102.3,64.34 102.09,64.12 102.09,63.96 102.25,63.8 102.41,63.8 102.63,64.01 102.79,64.01 102.95,63.85 102.95,63.69 102.74,63.47 102.74,63.31 102.9,63.15 103.06,63.15 103.27,63.37 103.44,63.37 103.6,63.2 103.6,63.04 103.38,62.83 103.38,62.67 103.54,62.5 103.71,62.5 103.92,62.72 104.08,62.72 104.24,62.56 104.24,62.4 104.03,62.18 104.03,62.02 104.19,61.86 104.35,61.86 104.57,62.07 104.73,62.07 104.89,61.91 104.89,61.75 104.68,61.53 104.68,61.37 104.84,61.21 105,61.21 105.21,61.43 105.38,61.43 105.54,61.26 105.54,61.1 105.32,60.89 105.32,60.73 105.48,60.56 105.65,60.56 105.86,60.78 106.02,60.78 106.18,60.62 106.18,60.46 105.97,60.24 105.97,60.08 106.13,59.92 106.29,59.92 106.51,60.13 106.67,60.13 107.47,59.33 140.1,59.33 147.56,51.88 147.56,49.29 v2(148,48.85)
  BOTTOM w0.14: CPU1.AL34 86.86,86.32 v2(86.86,86.32) ; DM2.161 148.52,51.09 148.52,49.37 v2(148,48.85)
M_B_DQ0: length 57.3
  L5 w0.114: v2(88.15,77.32) 88.14,77.32 87.64,76.82 87.64,74.35 88.2,73.79 88.2,64.21 93.45,58.95 93.45,58.79 93.14,58.48 93.14,58.31 93.3,58.15 93.46,58.15 93.78,58.47 93.94,58.47 94.1,58.31 94.1,58.14 93.69,57.74 93.69,57.58 93.85,57.41 94.01,57.41 94.42,57.82 94.58,57.82 94.75,57.66 94.75,57.5 94.34,57.09 94.34,56.93 94.5,56.77 94.66,56.77 95.07,57.17 95.23,57.17 95.39,57.01 95.39,56.85 94.98,56.44 94.98,56.28 95.15,56.12 95.31,56.12 95.72,56.53 95.88,56.53 96.04,56.37 96.04,56.2 95.63,55.8 95.63,55.64 95.79,55.47 95.95,55.47 96.36,55.88 96.52,55.88 96.69,55.72 96.69,55.56 96.28,55.15 96.28,54.99 96.53,54.74 97.64,54.74 102.49,49.89 105.44,49.89 106.42,48.91 v2(107.08,48.91)
  BOTTOM w0.076: CPU1.AN35 87.75,84.84 87.72,84.77 87.72,84.15 87.66,84.04 87.65,84.03 87.65,83.59 87.83,83.41 87.83,83.06 87.47,82.69 87.47,82.67 87.46,82.66 87.46,79.39 87.49,79.35
  BOTTOM w0.114: DM2.3 107.03,50.12 106.63,49.73 106.63,49.36 v2(107.08,48.91) ; 87.49,79.35 87.49,77.97 v2(88.15,77.32)
M_B_DQ1: length 55.3
  L5 w0.114: v2(88.14,79.25) 88.8,78.59 88.8,74.6 88.91,74.49 88.91,64.47 102.29,51.08 106.14,51.08 108.07,49.15 108.07,46.27 108.01,46.21 108.01,46.2 107.75,45.94 107.74,45.94 v2(107.5,45.7)
  BOTTOM w0.076: 88.91,79.97 89.06,80.11 89.06,83.49 88.94,83.6 88.94,83.98 88.98,84.07 88.98,84.29 88.94,84.38 88.94,84.63 89,84.79 89,85.36 89,85.65 88.85,85.81 CPU1.AN34
  BOTTOM w0.114: v2(88.14,79.25) 88.19,79.25 88.91,79.97 ; v2(107.5,45.7) 107.5,45.09 108.28,44.31 DM2.8
M_B_DQ2: length 57.9
  L5 w0.114: v2(90.34,75.11) 90.34,74.08 90.62,73.8 90.62,65.18 94.88,60.92 95.04,60.92 95.41,61.28 95.57,61.28 95.73,61.12 95.73,60.96 95.37,60.6 95.37,60.43 95.53,60.27 95.69,60.27 96.05,60.64 96.22,60.64 96.38,60.48 96.38,60.31 96.01,59.95 96.01,59.79 96.17,59.63 96.34,59.63 96.7,59.99 96.86,59.99 97.02,59.83 97.02,59.67 96.66,59.3 96.66,59.14 96.82,58.98 96.98,58.98 97.35,59.34 97.51,59.34 97.75,59.1 97.75,58.94 97.39,58.57 97.39,58.41 97.55,58.25 97.71,58.25 98.08,58.62 98.24,58.62 104.06,52.8 107.6,52.8 110.96,49.43 110.96,48.66 v2(111.46,48.17)
  BOTTOM w0.076: 88.98,79.45 89.22,79.69 89.22,83.55 89.12,83.66 89.12,83.98 89.14,84.04 89.14,84.32 89.12,84.39 89.12,84.63 89.28,85.06 CPU1.AR35
  BOTTOM w0.114: v2(90.34,75.11) 90.27,75.11 88.98,76.4 88.98,79.45 ; DM2.17 110.53,49.94 110.46,49.87 110.46,49.05 111.34,48.17 v2(111.46,48.17)
M_B_DQ3: length 57.2
  L5 w0.102: v2(109.74,46.02) 109.59,46.17 109.13,46.17 109,46.3 109,47.42 109.78,48.2
  L5 w0.114: 109.78,48.2 109.78,49.61 107.28,52.11 103.77,52.11 101.17,54.71 101.01,54.71 100.65,54.35 100.48,54.35 100.32,54.51 100.32,54.67 100.69,55.03 100.69,55.2 100.53,55.36 100.37,55.36 100,54.99 99.84,54.99 89.94,64.89 89.94,73.65 89.73,73.86 89.73,74.68 89.55,74.87 89.55,77.92 v2(90.18,78.55)
  BOTTOM w0.076: CPU1.AR34 89.64,85.26 89.64,84.31 89.79,84.03 89.79,83.62 89.72,83.55 89.72,79.01
  BOTTOM w0.089: 89.72,79.01 v2(90.18,78.55)
  BOTTOM w0.114: DM2.16 110.28,44.59 110.03,44.83 110.03,45.67 109.76,45.95 109.76,46 v2(109.74,46.02)
M_B_DQ4: length 55.8
  L5 w0.114: v2(88.03,82.46) 87.38,81.81 87.38,74.1 87.66,73.82 87.66,63.12 89.75,61.03 89.91,61.03 90.25,61.36 90.41,61.36 90.57,61.2 90.57,61.04 90.23,60.7 90.23,60.54 90.39,60.38 90.56,60.38 90.89,60.72 91.06,60.72 91.22,60.55 91.22,60.39 90.88,60.06 90.88,59.89 91.04,59.73 91.2,59.73 91.54,60.07 91.7,60.07 91.86,59.91 91.86,59.75 91.53,59.41 91.53,59.25 91.69,59.09 91.85,59.09 92.19,59.42 92.35,59.42 92.51,59.26 92.51,59.1 92.17,58.76 92.17,58.6 96.39,54.38 97.5,54.38 102.34,49.55 105.3,49.55 106.48,48.36 106.48,48.18 v2(107.08,47.58)
  BOTTOM w0.076: CPU1.AN37 88.16,83.77 88.16,83.52 88.16,83.2 88.18,83.18 88.18,82.59 88.05,82.46 v2(88.03,82.46)
  BOTTOM w0.114: DM2.7 108.03,48.32 107.29,47.58 v2(107.08,47.58)
M_B_DQ5: length 56.7
  L5 w0.114: v2(88.14,78.61) 88.37,78.61 88.56,78.43 88.56,77.15 88.54,77.13 88.54,64.35 97.32,55.57 102.15,50.74 102.98,50.74 103.1,50.63 103.1,50.36 103.21,50.24 103.44,50.24 103.56,50.36 103.56,50.63 103.67,50.74 103.9,50.74 104.01,50.63 104.01,50.36 104.13,50.24 104.36,50.24 104.47,50.36 104.47,50.63 104.58,50.74 105.07,50.74 105.54,50.28 105.7,50.28 106,50.58 106.16,50.58 106.32,50.42 106.32,50.25 106.02,49.96 106.02,49.79 106.24,49.57 106.45,49.57 106.71,49.84 106.89,49.84 107.73,49 107.73,47.2 v2(106.18,45.65)
  BOTTOM w0.076: CPU1.AN36 87.9,84.19 87.9,84.11 87.88,84.07 87.84,84.03 87.82,83.98 87.82,83.66 88,83.48 88,82.96 87.89,82.86 87.87,82.86 87.64,82.63 87.64,82.6 87.62,82.59 87.62,79.48 87.68,79.42 87.68,78.74 87.8,78.61 v2(88.14,78.61)
  BOTTOM w0.114: DM2.4 107.28,44.04 106.18,45.14 v2(106.18,45.65)
M_B_DQ6: length 57.8
  L5 w0.114: v2(110.67,46.69) 110.57,46.79 110.48,46.79 110.35,46.92 110.35,49.55 107.45,52.45 103.91,52.45 100.35,56.02 100.19,56.02 99.83,55.65 99.67,55.65 99.5,55.81 99.5,55.97 99.87,56.34 99.87,56.5 99.71,56.66 99.55,56.66 99.18,56.3 99.02,56.3 98.86,56.46 98.86,56.62 99.22,56.99 99.22,57.15 99.06,57.31 98.9,57.31 98.53,56.94 98.37,56.94 98.21,57.11 98.21,57.27 98.58,57.63 98.58,57.79 98.41,57.96 98.25,57.96 97.89,57.59 97.72,57.59 90.28,65.03 90.28,73.72 89.95,74.05 89.95,74.8 89.76,74.99 89.76,76.83 v2(90.19,77.26)
  BOTTOM w0.076: CPU1.AR36 89.37,84.45 89.63,83.99 89.63,83.69 89.55,83.61 89.55,79.54 89.54,79.53 89.54,78.78
  BOTTOM w0.114: 89.54,78.78 89.54,77.91 v2(90.19,77.26) ; DM2.20 111.28,44.69 110.88,45.08 110.88,46.38 110.67,46.58 v2(110.67,46.69)
M_B_DQ7: length 57.2
  L5 w0.114: v2(90.17,76.59) 90.17,76.39 90.76,75.81 90.76,74.13 90.97,73.92 90.97,66.4 91.6,65.77 91.6,65.6 91.22,65.23 91.22,65.06 91.38,64.9 91.55,64.9 91.92,65.28 92.08,65.28 92.25,65.12 92.25,64.96 91.87,64.58 91.87,64.42 92.03,64.26 92.19,64.26 92.57,64.63 92.73,64.63 92.89,64.47 92.89,64.31 92.52,63.93 92.52,63.77 92.68,63.61 92.84,63.61 93.22,63.99 93.38,63.99 93.54,63.83 93.54,63.66 93.16,63.29 93.16,63.12 93.32,62.96 93.49,62.96 93.86,63.34 94.02,63.34 94.19,63.18 94.19,63.02 93.81,62.64 93.81,62.48 93.97,62.32 94.13,62.32 94.51,62.69 94.67,62.69 94.83,62.53 94.83,62.37 94.46,61.99 94.46,61.83 94.62,61.67 94.78,61.67 95.16,62.05 95.32,62.05 95.91,61.45 96.07,61.45 96.17,61.55 96.33,61.55 96.49,61.39 96.49,61.22 96.4,61.13 96.4,60.97 96.56,60.81 96.72,60.81 96.82,60.9 96.98,60.9 97.14,60.74 97.14,60.58 97.04,60.48 97.04,60.32 97.21,60.16 97.37,60.16 97.46,60.25 97.63,60.25 97.79,60.09 97.79,59.93 97.69,59.84 97.69,59.67 97.85,59.51 98.01,59.51 98.11,59.61 98.27,59.61 98.43,59.45 98.43,59.28 98.34,59.19 98.34,59.03 98.5,58.87 98.66,58.87 98.76,58.96 98.92,58.96 99.08,58.8 99.08,58.64 98.98,58.54 98.98,58.38 104.22,53.14 107.77,53.14 v2(111.45,49.46)
  BOTTOM w0.076: CPU1.AR37 89.33,83.82 89.33,83.67 89.39,83.62 89.39,79.61 89.3,79.52 89.3,79.31
  BOTTOM w0.114: 89.3,79.31 89.3,77.47 v2(90.17,76.59) ; DM2.21 111.53,50.35 111.5,50.33 111.5,49.51 v2(111.45,49.46)
M_B_DQ8: length 57.1
  L5 w0.114: v2(113.41,48.25) 112.96,48.71 112.96,50.06 108.31,54.71 105.39,54.71 95.89,64.2 95.89,64.36 96.22,64.69 96.22,64.86 96.06,65.02 95.9,65.02 95.57,64.69 95.41,64.69 95.25,64.85 95.25,65.01 95.58,65.34 95.58,65.5 95.42,65.66 95.25,65.66 94.92,65.33 94.76,65.33 94.6,65.5 94.6,65.66 94.93,65.99 94.93,66.15 94.77,66.31 94.61,66.31 94.28,65.98 94.12,65.98 93.95,66.14 93.95,66.3 94.28,66.63 94.28,66.8 94.12,66.96 93.96,66.96 93.63,66.63 93.47,66.63 93.31,66.79 93.31,66.95 93.64,67.28 93.64,67.44 93.48,67.6 93.31,67.6 92.98,67.27 92.82,67.27 92.58,67.52 92.58,75.51 91.53,76.56 91.53,80.18 v2(90.55,81.15)
  BOTTOM w0.076: v2(90.55,81.15) 90.84,81.44 90.84,83.97 90.82,84.03 90.81,84.04 90.81,84.32 90.82,84.33 90.84,84.39 90.84,84.62 90.82,84.68 90.68,85.06 CPU1.AU35
  BOTTOM w0.114: v2(113.41,48.25) 112.53,49.14 112.53,51.1
M_B_DQ9: length 57.6
  L5 w0.114: v2(90.12,79.25) 90.12,79.19 90.6,78.71 90.6,76.27 91.45,75.42 91.45,67.19 91.69,66.95 91.69,66.79 91.53,66.62 91.53,66.46 91.69,66.3 91.85,66.3 92.01,66.46 92.18,66.46 92.34,66.3 92.34,66.14 92.17,65.98 92.17,65.82 92.34,65.65 92.5,65.65 92.66,65.82 92.82,65.82 92.98,65.66 92.98,65.49 92.82,65.33 92.82,65.17 92.98,65.01 93.14,65.01 93.31,65.17 93.47,65.17 93.63,65.01 93.63,64.85 93.47,64.68 93.47,64.52 93.63,64.36 93.79,64.36 93.95,64.52 94.12,64.52 99.7,58.94 99.7,58.33 104.53,53.5 108.06,53.5 111.93,49.63 111.93,47.66 111.8,47.53 v2(111.49,47.53)
  BOTTOM w0.076: CPU1.AU34 90.59,85.8 90.3,85.2 90.3,84.26 90.26,84.19 90.16,84.01 90.16,84 90.1,83.89 90.09,83.88 90.09,83.69 89.88,83.48 89.88,79.52 90.12,79.27 v2(90.12,79.25)
  BOTTOM w0.114: v2(111.49,47.53) 111.89,47.13 111.89,47.08 111.92,47.05 111.92,45.46 112.14,45.24 112.14,44.88 112.28,44.75 DM2.24
M_B_DQ10: length 59.4
  L5 w0.114: v2(92.41,80.62) 93.02,80.62 95.18,78.46 95.18,72.76 95.18,70.74 99.38,66.54 99.38,66.38 98.64,65.63 98.64,65.47 98.8,65.31 98.96,65.31 99.71,66.05 99.87,66.05 100.03,65.89 100.03,65.73 99.31,65.01 99.31,64.82 99.45,64.68 99.62,64.68 100.35,65.41 100.52,65.41 100.68,65.25 100.68,65.08 99.96,64.36 99.96,64.18 100.11,64.03 100.27,64.03 101,64.76 101.16,64.76 101.32,64.6 101.32,64.44 100.7,63.81 100.7,63.63 100.85,63.48 101.02,63.48 101.65,64.11 101.81,64.11 101.97,63.95 101.97,63.79 101.3,63.12 101.3,62.96 101.54,62.71 103.21,62.71 115.59,50.34 115.59,49.16 115.71,49.03 v2(116.02,49.03)
  BOTTOM w0.076: v2(92.41,80.62) 92.41,82.52 92.07,82.87 92.07,83.37 92.31,83.62 92.31,84.03 92.22,84.19 92.2,84.23 92.2,84.85 CPU1.AW35
  BOTTOM w0.114: v2(116.02,49.03) 115.53,49.53 DM2.37
M_B_DQ11: length 57.8
  L5 w0.114: v2(90.54,80.52) 90.56,80.52 91.31,79.76 91.31,76.47 92.24,75.55 92.24,67.37 105.25,54.36 108.16,54.36 112.61,49.91 112.61,48.42 112.98,48.05 112.98,47.32 113.82,46.47 115.04,46.47 v2(115.49,46.91)
  BOTTOM w0.076: 90.94,80.9 91.04,81 91.04,83.92 90.98,84.09 90.98,84.27 91.02,84.39 91.02,84.62 90.93,84.86 90.93,84.86 90.89,84.97 90.89,85.62 91.08,85.81 CPU1.AW34
  BOTTOM w0.114: v2(90.54,80.52) 90.56,80.52 90.94,80.9 ; v2(115.49,46.91) 115.78,46.62 DM2.38
M_B_DQ12: length 57.1
  L5 w0.114: v2(90.44,81.79) 90.5,81.79 91.74,80.55 91.74,76.65 92.92,75.47 92.92,68.64 97.01,64.55 97.01,64.39 96.68,64.06 96.68,63.9 96.84,63.74 97.01,63.74 97.34,64.07 97.5,64.07 97.66,63.9 97.66,63.74 97.33,63.41 97.33,63.25 97.49,63.09 97.65,63.09 97.98,63.42 98.15,63.42 98.31,63.26 98.31,63.1 97.98,62.77 97.98,62.6 98.14,62.44 98.3,62.44 98.63,62.77 98.79,62.77 98.95,62.61 98.95,62.45 98.62,62.12 98.62,61.96 98.78,61.8 98.95,61.8 99.28,62.13 99.44,62.13 99.68,61.89 99.68,61.71 99.36,61.4 99.36,61.22 99.9,60.68 100.07,60.68 100.38,60.99 100.56,60.99 100.71,60.84 100.71,60.68 100.39,60.35 100.39,60.19 100.55,60.03 100.71,60.03 101.02,60.34 101.19,60.34 101.34,60.19 101.34,60.01 101.04,59.71 101.04,59.55 101.73,58.85 101.89,58.85 102.22,59.18 102.38,59.18 102.54,59.02 102.54,58.86 102.21,58.53 102.21,58.37 102.38,58.21 102.54,58.21 102.87,58.54 103.03,58.54 103.19,58.37 103.19,58.21 102.86,57.88 102.86,57.72 103.02,57.56 103.18,57.56 103.33,57.7 103.52,57.7 103.66,57.56 103.66,57.39 103.51,57.24 103.51,57.07 105.53,55.05 108.45,55.05 113.43,50.07 v2(113.43,49.52)
  BOTTOM w0.114: v2(90.44,81.79) 90.44,83.16 90.59,83.31 CPU1.AU37 ; v2(113.43,49.52) 113.53,49.62 DM2.29
M_B_DQ13: length 57.3
  L5 w0.114: v2(90.8,79.16) 91.09,78.86 91.09,76.12 91.89,75.32 91.89,67.23 100.49,58.63 100.49,58.47 100.35,58.33 100.35,58.16 100.51,58 100.68,58 100.82,58.15 100.98,58.15 101.14,57.98 101.14,57.82 101,57.68 101,57.52 101.16,57.36 101.32,57.36 101.46,57.5 101.63,57.5 101.79,57.34 101.79,57.18 101.65,57.03 101.65,56.87 101.81,56.71 101.97,56.71 102.11,56.85 102.27,56.85 102.43,56.69 102.43,56.53 102.29,56.39 102.29,56.22 102.45,56.06 102.62,56.06 102.76,56.21 102.92,56.21 103.08,56.04 103.08,55.88 102.94,55.74 102.94,55.58 103.1,55.42 103.26,55.42 103.4,55.56 103.57,55.56 103.73,55.4 103.73,55.24 103.59,55.09 103.59,54.93 103.75,54.77 103.91,54.77 104.05,54.91 104.21,54.91 104.37,54.75 104.37,54.59 104.23,54.45 104.23,54.28 104.39,54.12 104.56,54.12 104.7,54.27 104.86,54.27 105.1,54.02 108.02,54.02 112.27,49.77 112.27,47.82 v2(112.54,47.55)
  BOTTOM w0.076: v2(90.8,79.16) 90.78,79.16 90.05,79.89 90.05,83.41 90.26,83.62 90.32,83.74 90.32,83.97 90.37,84.05 90.51,84.32 90.59,84.45 CPU1.AU36
  BOTTOM w0.114: DM2.28 113.28,44.74 113.03,44.98 113.03,47.05 v2(112.54,47.55)
