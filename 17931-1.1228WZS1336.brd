# Allegro board 17931-1.1228WZS1336.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB4_USB31_TX_N: length 153.4
  L6 w0.102: v2(23.39,44.18) 23.71,44.5 24.07,44.5 24.28,44.7 24.28,49.67 27.26,52.66 29.91,52.66 31.76,54.51 32.8,54.51 34.45,56.16 34.45,56.89 38.59,61.03 38.59,62.88 42.44,66.74 42.98,66.74 45.22,68.98 45.22,70.3 47.36,72.44 49.73,72.44 49.99,72.7 49.99,73.2 50.52,73.73 50.52,77.68 51.25,78.41 52.21,78.41 54.63,80.83 54.63,88.85 52.58,90.9 52.58,93.33 51.34,94.58 51.34,99.05 56.11,103.83 56.11,109.17 57.61,110.67 62.89,110.67 67.9,115.67 88.81,115.67 89.63,116.49 90.83,116.49 91.72,117.37 100.55,117.37 101.56,116.36 104.43,116.36 106.63,114.16 106.63,113.25 106.51,113.13 106.38,113.13 v2(106.15,113.35)
  BOTTOM w0.076: CPU1.BY4 104.66,105.11 104.36,105.41 104.36,106.01 104.57,106.22 104.57,107.77 104.68,107.88 104.68,107.88 104.78,107.99 104.78,108.1 104.76,108.11 104.76,108.12
  BOTTOM w0.114: C3523.1 22.53,44.27 22.79,44.53 23.03,44.53 v2(23.39,44.18) ; 104.76,108.12 104.76,110.91 105.46,111.61 105.46,112.85 105.71,113.09 105.89,113.09 v2(106.15,113.35)
USB4_USB31_TX_P: length 152.6
  L6 w0.102: v2(23.39,44.81) 23.49,44.7 23.99,44.7 24.07,44.79 24.07,49.75 27.18,52.86 29.82,52.86 31.68,54.71 32.71,54.71 34.24,56.24 34.24,56.97 38.38,61.11 38.38,62.97 42.36,66.94 42.89,66.94 45.01,69.06 45.01,70.38 47.27,72.65 49.64,72.65 49.79,72.79 49.79,73.28 50.32,73.81 50.32,77.76 51.17,78.61 52.13,78.61 54.43,80.92 54.43,88.77 52.38,90.82 52.38,93.25 51.13,94.49 51.13,99.14 55.91,103.91 55.91,109.25 57.52,110.87 62.81,110.87 67.82,115.88 88.73,115.88 89.54,116.69 90.75,116.69 91.63,117.58 100.63,117.58 101.64,116.57 104.52,116.57 106.84,114.25 106.84,113.17 106.59,112.92 106.39,112.92 v2(106.15,112.68)
  BOTTOM w0.076: CPU1.BY3 104.54,105.64 104.54,105.94 104.75,106.14 104.75,107.7 104.86,107.81 104.86,107.81 104.96,107.91 104.96,108.04 104.96,108.08 104.99,108.11 104.99,108.12
  BOTTOM w0.114: v2(106.15,112.68) 105.97,112.86 105.8,112.86 105.69,112.75 105.69,111.51 104.99,110.81 104.99,108.12 ; v2(23.39,44.81) 23.33,44.76 22.71,44.76 C3522.1
USB30_PS_VCC: length 7.4
  TOP w0.305: U3601.12 21.51,49.45
  L3 w0.508: 13.14,58.31 USB1.1 13.14,59.99
  L3 w1.016: USB1.1 14.95,59.15
  BOTTOM w0.305: ED3502.5 v2(15.75,47.04)
  BOTTOM w0.508: 13.14,60.2 USB1.1 14.35,59.15
  vias: v1(17.73,45.77) v1(19.71,45.37) v1(21.21,47.68) v4(9.88,45.85) v4(10.44,46.53)
USB_ADT: length 363.8
  L3 w0.305: v2(29.26,95.45) 29.26,94.37 30.91,92.72 39.04,92.72 39.93,91.83 39.93,77.32 36.55,73.94 35.47,73.94 34.57,73.04 30.02,73.04 28.61,71.63 26.24,71.63 23.85,69.24 23.85,67.31 23.75,67.21 23.75,67.19 23.7,67.14 23.7,62.23 22.25,60.78 22.25,59.32 19.13,56.19 19.13,49.76 18.84,49.47 18.84,43.09 18.27,42.51 18.27,36.63 19.38,35.51 19.38,29.19 23.48,25.1 30.38,25.1 31.29,24.19 31.29,23.88 31.3,23.88 31.3,23.6 v2(31.12,23.42)
  L5 w0.152: v2(193.3,33.96) 192.31,32.97 187.73,32.97 187.02,32.26 175.03,32.26 174.15,33.14 171.74,33.14 170.8,32.2 148.78,32.2 147.37,33.61 145.06,33.61 144.44,32.98 137.77,32.98 137.05,33.7 135.27,33.7 132.02,36.96 130.45,36.96 124.7,42.71 112.23,42.71 110.84,41.32 110.84,37.7 110.16,37.02 110.16,35.98 108.68,34.5 108.68,33.91 106.25,31.48 90.39,31.48 89.03,30.12 37.54,30.12 35.28,27.86 35.28,26.5 34.27,25.48 33.29,25.48 31.22,23.42 v2(31.12,23.42)
  L5 w0.305: v2(35.51,132.67) 35.03,133.16 30.54,133.16 29.54,132.17 29.54,130.81 22.85,124.12 22.85,121.45 20.45,119.05 18.91,119.05 16.97,117.11 16.97,114.19 18.16,113 18.16,112.73 22.53,108.36 22.53,107.57 23.17,106.94 23.17,101.3 27.18,97.28 27.18,96.86 28.58,95.45 v2(29.26,95.45)
  L6 w0.305: v4(38.31,122) 38.31,123.03 38.74,123.46 38.74,126.76 38.28,127.22 38.28,131.34 36.93,132.7 35.54,132.7 v2(35.51,132.67)
  BOTTOM w0.152: v2(193.3,33.96) 192.87,34.39 192.87,37.19 192.71,37.34 192.71,39.65 PD4407.A
  BOTTOM w0.254: PD4409.A 192.03,41.2 192.92,41.2 193.99,40.12 PD4408.2 192.9,39.89 PD4407.A
  BOTTOM w0.356: v2(29.26,95.45) v1(28.68,95.45)
USB_EN#: length 264.8
  TOP w0.089: v2(20.81,65.18) 20.91,65.28 21.3,65.28 22.07,66.05 22.07,66.05 22.08,66.05 22.09,66.05 22.34,66.3 22.34,67.27 22.76,67.69 U2401.13 ; v2(198.15,39.47) 198.5,39.12 AFTP6614.1
  L3 w0.089: v2(23.3,22.07) 23.53,22.3 23.53,23.01 23.32,23.22 23.12,23.22 15.83,30.51 15.83,34.85 16.53,35.56 16.53,38.54 15.42,39.65 15.42,41.04 v2(15.9,41.52) 15.9,42.24 17.36,43.7 17.36,48.39 17.36,48.4 17.36,50.08 17.64,50.36 17.64,57.97 19.71,60.04 19.71,64.16 20.73,65.18 v2(20.81,65.18) ; v2(167.61,33.78) 167.15,34.23 166.4,34.23 166.27,34.36 151.17,34.36 149.98,33.17 146.25,33.17 v2(145.75,32.67)
  L5 w0.089: v2(145.75,32.67) 145.32,32.23 137.59,32.23 137.09,32.74 135.58,32.74 135.19,32.34 133.02,32.34 130.7,34.66 129.94,34.66 129.58,35.02 129.58,35.03 127.31,37.3 127.31,38.26 124.08,41.5 112.73,41.5 112.05,40.82 112.05,37.2 111.67,36.82 111.67,34.84 106.18,29.34 94.72,29.34 94.06,30.01 91.22,30.01 89.71,28.5 46.16,28.5 45.68,28.02 40.41,28.02 34.67,22.28 34.67,21.9 33.45,20.68 33.13,20.68 31.92,19.47 29.95,19.47 29.65,19.17 25.52,19.17 23.3,21.39 v2(23.3,22.07)
  L6 w0.089: v2(167.61,33.78) 168.39,33 186.29,33 188.53,35.24 192.15,35.24 192.38,35 197.39,35 198.4,36.02 198.4,39.22 v2(198.15,39.47)
  BOTTOM w0.089: U3502.4 18.75,42.06 16.44,42.06 v2(15.9,41.52) ; v2(20.81,65.18) 20.4,65.58 19.12,65.58 18.62,65.08 18.49,65.08 R2434.2 ; IOBD1.12 197.8,39.12 v2(198.15,39.47)
USB_OC0#: length 229.6
  TOP w0.089: v2(32.65,22.49) 32.82,22.66 32.82,23.65 35.23,26.06 35.23,27.7 v1(38.39,30.87) 39.19,31.66 50.42,31.66 50.57,31.66 53.04,34.13 53.31,34.41 53.31,35.73 52.62,36.42 52.62,40.46 53.5,41.33 53.5,41.48 53.5,42.29 52.89,42.9 52.89,50.39 57.01,54.51 111.09,54.51 126.87,70.29 126.87,73.08 126.42,73.53 126.42,97.12 125.38,98.15 125.38,103.63 124.27,104.74 124.27,105.7 v2(123.68,106.3) ; v2(13.39,23.22) 13.39,23.93 14.72,25.27 14.72,29.6 18.14,33.02 18.14,39.02 18.75,39.63 18.75,40.21 18.01,40.95 18.01,42.88 18.37,43.23 R3512.1 R3607.2
  L3 w0.089: v2(123.68,106.3) 124.11,105.87 124.11,105.26 123.79,104.95 121.83,104.95 121.07,104.19 112.71,104.19 v2(111.26,102.74)
  L5 w0.089: v2(13.39,23.22) 13.8,23.63 13.8,23.98 15.32,25.5 19.57,25.5 21.47,23.6 24.03,23.6 25.67,21.96 30.52,21.96 30.91,22.35 32.11,22.35 32.24,22.49 v2(32.65,22.49)
  BOTTOM w0.089: RN1601.7 125.66,106.6 125.03,105.97 124.01,105.97 v2(123.68,106.3) ; CPU1.CK6 111.04,102.74 v2(111.26,102.74)
USB_OC1#: length 228.6
  TOP w0.089: v2(123.68,105.67) 123.68,104.95 125.14,103.49 125.14,98.14 126.24,97.04 126.24,70.67 v2(126.44,70.47) ; v2(200.74,37.82) 200.74,38.13 AFTP6613.1 ; v2(219.21,68.23) 218.24,67.26 212.14,67.26 211.43,66.55 191.54,66.55 190.33,65.33 190.33,64.07 187.63,61.37 183.33,61.37 180.88,63.83 180.88,66.98 177.71,70.15 177.71,70.74 177.79,70.82 177.79,71.47 v2(177.78,71.48)
  L3 w0.089: v2(123.68,105.67) 123.13,105.12 121.75,105.12 121.01,104.38 112.13,104.38 v2(111.1,103.36) ; v2(224.41,38.24) 225.19,39.02 225.19,67.32 224.53,67.98 224.53,68.61 224.28,68.85 220.81,68.85 220.18,68.23 v2(219.21,68.23)
  L6 w0.089: v2(224.41,38.24) 223.93,37.76 223.93,37.52 221.7,35.29 219.28,35.29 216.8,37.77 213.06,37.77 212.88,37.95 208.79,37.95 208.08,37.24 204.93,37.24 204.7,37.01 201.55,37.01 v2(200.74,37.82)
  BOTTOM w0.089: IOBD1.11 198.3,38.23 199.16,37.37 200.28,37.37 200.73,37.82 v2(200.74,37.82) ; CPU1.CK5 111.07,103.36 v2(111.1,103.36) ; v2(123.68,105.67) 124.26,105.08 125.45,105.08 125.89,105.51 RN1601.5 ; v2(177.78,71.48) 177.79,71.47 177.79,70.82 174.77,67.81 158.33,67.81 155.69,70.45 145.63,70.45 144.98,71.11 135.66,71.11 135.02,70.47 v2(126.44,70.47)
USB_OC1#_R: length 10.6
  TOP w0.089: R3512.2 21.14,42.88 20.88,42.62 19.15,42.62 18.98,42.8 v1(18.47,42.8) 18.19,42.52 18.19,41.02 18.52,40.69 v2(20.12,40.69)
  BOTTOM w0.089: v2(20.12,40.69) 18.62,40.69 17.92,41.39 U3502.3
USB_OC2#: length 21.2
  TOP w0.089: v1(126.7,106.4) v2(124.74,106.4)
  L3 w0.089: v2(124.74,106.4) 124.29,105.94 124.29,104.09 123.07,102.87 119.74,102.87 119.05,103.56 117.07,103.56 116.79,103.28 113.14,103.28 111.98,102.12 v2(111.1,102.12)
  BOTTOM w0.089: v2(111.1,102.12) 111.09,102.12 110.81,101.84 CPU1.CK8 ; v2(124.74,106.4) 125.53,107.19 RN1601.8
USB_OC3#: length 20.5
  TOP w0.089: v1(110.65,101.12) 110.31,101.45 v2(110.19,101.45)
  L3 w0.089: v2(124.74,105.54) 124.74,104.29 123.14,102.69 119.66,102.69 119,103.36 117.66,103.36 117.35,103.05 113.27,103.05 111.31,101.09 110.55,101.09 v2(110.19,101.45)
  BOTTOM w0.089: v2(110.19,101.45) 110.38,101.45 CPU1.CK9 ; v2(124.74,105.54) 124.89,105.54 125.46,106.1 RN1601.6
USB_POWERSHARE_VBUS_EN: length 37.1
  TOP w0.089: U2401.71 38.31,62.49 37.87,62.05 v2(37.87,62.03) ; U3601.5 19.28,53.55 18.55,54.28 v1(16.92,54.28) 16.03,53.39 16.03,51.31 v2(16.87,50.47)
  L6 w0.089: v2(26.36,52.85) 26.75,53.24 29.64,53.24 31.66,55.25 32.72,55.25 33.71,56.24 33.71,57.2 37.87,61.37 v2(37.87,62.03)
  BOTTOM w0.089: v2(26.36,52.85) 24.13,50.62 22.2,50.62 21.64,51.18 20.61,51.18 20.26,51.54 17.93,51.54 v2(16.87,50.47)
USB_PWR_SHR_EN_L#: length 36.4
  TOP w0.089: v2(28.6,70.23) 28.6,71.96 29.16,72.51 U2401.118 ; R3601.1 v2(16.92,51.76) 16.75,51.76 v1(16.45,51.45)
  L5 w0.089: v2(16.92,51.76) 16.92,51.76 17.45,52.29 17.45,56.99 21.58,61.11 22.5,61.11 23.06,61.67 23.06,62.19 25.6,64.74 25.6,66.83 26.31,67.54 26.92,67.54 27.59,68.2 27.59,69.43 27.86,69.7 28.07,69.7 v2(28.6,70.23)
  BOTTOM w0.089: v2(28.6,70.23) 29,69.83 29,69.37 28.44,68.81 26.85,68.81 26.29,68.25 25.16,68.25 24.82,68.25 24.34,67.77 R2492.2
USBC1_CC1_CONN: length 55.6
  TOP w0.254: U7201.6 42.91,111.66 42.98,111.74 43.51,111.74 43.82,111.43 C7208.1 44.89,111.43 v2(44.94,111.48) ; ED7315.2 10.57,119.23 v2(10.21,119.58)
  TOP w0.305: AFTP7303.1 9.09,123.44 v2(9.09,123.09)
  L6 w0.381: 9.64,122.23 9.67,122.25 13.8,122.25 14.28,122.73 17.02,122.73 17.78,123.5 19.05,123.5 19.56,122.99 24.26,122.99 27.46,119.79 27.46,119.03 27.88,118.61 28.54,118.61 30.33,120.4 v2(30.69,120.4) ; 9.64,122.23 9.64,122.66 9.22,123.09 v2(9.09,123.09) ; 9.64,122.23 9.64,121.98 9.16,121.5 9.16,121.02 10.21,119.97 v2(10.21,119.58)
  BOTTOM w0.191: v2(9.09,123.09) 9,123.18 8.29,123.18 8.06,122.95 JUSB1.A5
  BOTTOM w0.381: v2(44.94,111.48) 44.91,111.48 43.84,112.55 40.8,112.55 40.4,112.95 40.4,114.52 39.37,115.55 37.44,115.55 35.45,117.53 35.33,117.65 35.21,117.65 35.18,117.68 32.64,117.68 32.08,118.24 30.75,118.24 30.1,118.89 30.1,120.01 30.48,120.4 v2(30.69,120.4)
USBC1_CC2_CONN: length 59.6
  TOP w0.254: v2(12.89,118.44) ED7315.1
  TOP w0.305: U7201.4 43.61,110.66 C7209.1 44.63,110.87 v2(44.71,110.8)
  L6 w0.089: 8.13,121.62 6.66,121.62 6.45,121.83 6.21,122.27 6.2,122.46 6.3,122.8 6.3,122.99 6.15,123.22 6.15,124.21 JUSB1.B5 6.17,124.92 6.26,125.26 6.48,125.48 7.55,125.48 8.13,124.89
  L6 w0.381: 8.13,124.89 8.13,121.62 8.52,121.22 8.52,120.8 8.61,120.68 9.53,119.76 9.53,119.31 10.14,118.7 12.64,118.7 v2(12.89,118.44)
  BOTTOM w0.381: v2(12.89,118.44) 13.37,117.96 16.49,117.96 18.86,120.33 25.92,120.33 26.72,119.53 26.72,118.06 27.03,117.76 AFTP7304.1 30.34,117.76 30.49,117.6 31.75,117.6 32.34,117.02 35.06,117.02 37.22,114.86 39.09,114.86 39.58,114.38 39.58,112.62 40.39,111.81 43.56,111.81 44.57,110.8 v2(44.71,110.8)
USBCOMP: length 2
  TOP w0.114: R1603.1 107.38,104.76 v2(107.38,104.12) 107.6,103.9 v1(107.89,103.9)
  BOTTOM w0.114: CPU1.CC5 107.09,103.75 107.14,103.75 107.38,103.99 v2(107.38,104.12)
V_SM_VREF_CNTA: length 84.1
  TOP w0.305: v2(78.74,41.58) 78.74,40.78 77.74,39.77 v1(76.41,39.77) 74.3,39.77 C1222.1 73.99,40.08 R1206.2
  L3 w0.305: v2(74.02,71.98) 74.02,70.5 94.43,50.09 94.77,50.09 95.46,49.41 95.46,48.41 96.4,47.47 96.4,45.51 96.65,45.26 96.65,43.99 95.25,42.6 94.16,42.6 92.33,40.77 79.56,40.77 v2(78.74,41.58)
  BOTTOM w0.203: CPU1.F36 71.78,84.25 71.4,83.87 71.4,83.6 70.92,83.12 69.51,83.12 68.91,82.53
  BOTTOM w0.254: 68.91,82.53 67.36,80.98 67.36,75.05 70.43,71.98 v2(74.02,71.98)
V_SM_VREF_CNTB: length 109.4
  TOP w0.305: v2(144.2,41.99) 144.48,41.71 145.69,41.71 v1(145.94,41.96) 146,42.02 C1323.1 146.74,43.51 R1305.2
  L3 w0.305: v2(144.2,41.99) 144.2,42.89 143.47,43.61 129.59,43.61 129.19,44.02 104.28,44.02 102.66,45.64 102.66,45.73 97.68,50.71 96.26,50.71 95.48,51.5 95.14,51.5 75.89,70.75 75.54,71.61 v2(75.19,71.96)
  BOTTOM w0.254: CPU1.E36 71.05,84.05 71.05,83.7 70.81,83.46 68.91,83.46 66.6,81.15 66.6,74.73 70.11,71.22 74.45,71.22 v2(75.19,71.96)
VCI_IN1#: length 2.8
  TOP w0.089: v2(25.9,72.82) 25.95,72.87 U2401.126
  BOTTOM w0.089: v1(24.58,72.31) 24.65,72.24 R2496.1 25.9,72.66 v2(25.9,72.82)
VCREF0: length 5.7
  TOP w0.203: 25.01,63.04 25,63.05 24.58,63.05 24.43,62.89 U2401.25
  TOP w0.254: v2(25.43,62.54) 25.43,62.62 25.01,63.04
  BOTTOM w0.254: R2424.1 23.96,61.82 R2448.1 23.83,62.63 C2409.1 23.84,63.29 24.63,63.29 v1(24.64,63.3) 24.75,63.3 25.3,62.75 25.3,62.66 v2(25.43,62.54)
VGA_CORE_DISCHG: length 5.4
  TOP w0.305: R8706.2 106,143.66 106.94,143.66 v1(107.01,143.74) 106.56,144.2 v2(106.56,144.53)
  BOTTOM w0.305: Q8703.3 106.99,146.1 106.91,146.03 106.91,145.24 R8702.2 106.91,145.19 106.91,145.03 106.66,144.77 106.66,144.67 106.56,144.56 v2(106.56,144.53) 106.56,144.51 105.86,143.81 Q8705.3
VGA_CORE_PSI: length 60.3
  TOP w0.114: v2(134.45,109.27) v1(133.78,109.09)
  L6 w0.114: v2(134.45,109.27) 134.45,106.26 134.25,106.06 134.25,102.88 134.69,102.44 134.69,101.52 133.87,100.7 133.87,98.79 134.45,98.2 134.93,98.2 136.8,96.33 136.8,92.82 136.8,92.21 135.6,91.01 135.6,81.6 139.9,77.3 142.65,77.3 143.33,76.61 152.86,76.61 v2(153.64,77.4)
  BOTTOM w0.114: R7913.2 136.71,112.68 136.71,111.15 136.17,110.62 135.78,110.62 135.21,110.04 R7966.2 134.6,109.42 v2(134.45,109.27) ; PR8522.1 151.47,77.69 152.2,76.96 153.2,76.96 v2(153.64,77.4)
VGA_CORE_VID: length 58.2
  L6 w0.114: v2(135.39,108.36) 135.39,108.1 135.33,108.03 135.33,107.62 135.39,107.55 135.39,106.79 134.54,105.94 134.54,103 134.98,102.56 134.98,101.4 134.16,100.57 134.16,98.91 134.57,98.5 135.05,98.5 137.1,96.45 137.1,92.95 137.1,92.09 135.89,90.88 135.89,81.72 140.02,77.59 142.77,77.59 143.45,76.91 152.52,76.91 v2(153,77.4)
  BOTTOM w0.114: PR8510.1 149.71,79.58 149.93,79.8 149.93,80 149.94,80.01 149.94,80.26 150.07,80.38 151.77,80.38 151.97,80.18 151.97,77.84 152.42,77.4 v2(153,77.4) ; v2(135.39,108.36) 134.92,108.36 v1(134.8,108.24) 134.27,107.71 R7960.2 134.5,107.21 R7961.2
VGA_CORE_VID_R: length 24.7
  L6 w0.089: v2(138.37,104.8) 138.36,104.8 137.59,105.57 137.59,116.79 136.89,117.5 136.89,119.87 135.89,120.86 v2(135.89,120.87)
  BOTTOM w0.089: v2(138.37,104.8) v1(137.75,104.8) 137.33,104.39 135.77,104.39 135.44,104.73 135.44,105.69 135.18,105.94 134.8,105.94 134.7,105.84 R7959.1 134.27,106.4 R7960.1 ; GPU1.C6 v2(135.89,120.87)
VGA_CT_1: length 2.6
  BOTTOM w0.127: U8601.12 163.08,109.77 v1(162.51,110.34) 162.36,110.49 C8608.1
VGA_DB_DET#: length 116
  TOP w0.089: R5601.2 201.81,62.66 v2(202.06,62.92) 202.7,62.92 AFTP5601.1 R2059.2
  L6 w0.089: v2(202.06,62.92) 200.81,61.67 191.11,61.67 189.38,59.94 184.45,59.94 180.42,63.97 180.42,66.38 178.54,68.26 177.81,68.26 177.25,68.82 176.42,68.82 175.91,69.32 173.1,69.32 172.34,70.08 163.99,70.08 163.05,71.02 160.53,71.02 159.99,71.56 132.06,71.56 128.69,74.93 128.69,88.76 128.22,89.23 v2(128.22,89.24)
  BOTTOM w0.089: CPU1.CR24 113.59,91.96 114.82,91.96 115.34,91.44 119.08,91.44 119.76,90.76 127.05,90.76 127.8,90 127.8,89.66 v2(128.22,89.24)
VGA_DB_DET#_R: length 10.9
  TOP w0.089: v2(201.3,62.92) 200.21,62.92 v1(200.08,62.79) 200.59,62.28 R5601.1
  BOTTOM w0.089: v2(201.3,62.92) 199.29,60.9 195.73,60.9 195.45,60.63 VGABD1.19
VGA_NVVDD: length 3.1
  BOTTOM w0.127: Q8703.6 104.86,147.67 104.73,147.8 v1(104.22,147.8) 104.22,147.02 R8701.1 104.37,147.02 Q8703.5
VGA_PWR_EN#: length 3.5
  TOP w0.089: Q8701.5 103.43,142.97 R8703.1 103.7,142.7 v1(104.53,142.7) 104.08,143.14 Q8701.6
VGACORE_GND_SENSE_1: length 50.4
  L6 w0.254: v2(130.68,120.3) 131.45,119.53 131.45,116.86 133.67,114.63 133.67,111.59 132.6,110.51 132.6,109.64 133.59,108.64 133.59,106.5 133.31,106.22 133.31,102.14 133.13,101.95 133.13,97.43 136.06,94.49 136.06,92.52 134.85,91.31 134.85,87.94 134.21,87.29 134.21,81.52 137.46,78.26 137.56,78.26 137.59,78.26 v2(137.75,78.11)
  BOTTOM w0.254: v1(137.16,78.33) 137.39,78.11 v2(137.75,78.11) 138.03,78.11 138.31,78.39 PR8520.2 ; v2(130.68,120.3) GPU1.F1
VGACORE_VDD_SENSE_1: length 50.5
  TOP w0.254: v2(137.77,78.77) 137.77,79.71 v1(137.72,79.76)
  L6 w0.254: v2(137.77,78.77) 137.5,78.77 134.59,81.67 134.59,87.14 135.23,87.78 135.23,88.09 135.23,91.15 136.44,92.36 136.44,92.67 136.44,94.65 133.51,97.59 133.51,101.79 133.7,101.98 133.7,106.06 133.98,106.34 133.98,108.8 132.98,109.8 132.98,110.35 134.05,111.43 134.05,114.79 131.83,117.02 131.83,119.69 131.24,120.28 v2(131.24,120.85)
  BOTTOM w0.254: PR8517.2 138.46,79.15 138.08,78.77 v2(137.77,78.77) ; v2(131.24,120.85) GPU1.F2
VID_PLLVDD: length 3.1
  TOP w0.508: R7943.2 128.96,128.48 v2(128.96,127.89) v1(128.96,127.33)
  BOTTOM w0.305: GPU1.N6 129.46,127.39 v2(128.96,127.89)
VID_PLLVDD_L: length 0.8
  BOTTOM w0.305: GPU1.M6 130.74,126.11 v2(130.81,126.04)
  vias: v1(130.25,126.09)
VIDEO_CLK_XTAL_SS: length 2.9
  BOTTOM w0.114: GPU1.A10 140.08,120.78 R7901.1 139.68,120.27 v1(139.38,120.27)
VR_CAP: length 3
  TOP w0.203: v2(24.92,65.58) 24.81,65.69 U2401.18
  BOTTOM w0.254: v1(23.93,65.08) 23.93,65.38 24.21,65.66 C2418.1 24.49,65.86 24.77,65.58 v2(24.92,65.58)
VR_EN: length 2
  BOTTOM w0.089: PU4601.40 81.13,152.3 v1(81.18,152.35) 81.28,152.45 R4002.2
VR_RDY: length 3.8
  BOTTOM w0.089: PR4609.2 82.68,153.47 TP4601.1 81.24,152.81 81.06,152.81 80.86,152.58 80.73,152.44 PU4601.39
VRALERT#: length 3.3
  BOTTOM w0.089: TP1708.1 107.52,82.07 107.3,82.29 107.3,83.4 107.32,83.42 107.32,84.18 CPU1.CC36
VRAM_ID1: length 31
  L3 w0.089: v2(125.05,94.74) 124.69,94.39 124.69,89.33 122.22,86.86 120.61,86.86 119.59,87.89 118.9,87.89 118.21,87.2 118.21,87.03 117.1,85.92 115.83,85.92 114.32,87.44 112.66,87.44 111.46,88.65 111.07,88.65 110.39,89.33 110.39,89.96 109.88,90.48 v2(109.03,90.48)
  BOTTOM w0.089: CPU1.CE27 108.01,90.1 108.38,90.48 v2(109.03,90.48) ; v2(125.05,94.74) v1(125.68,94.74) 126.62,94.74 R2008.2 127.08,94.34 127.87,94.34 R2007.1
VRAM_ID2: length 18.8
  BOTTOM w0.076: 115.16,92.18 115.05,92.3 113.93,92.3 113.81,92.42 113.4,92.42 113.34,92.39 113.11,92.39 113.04,92.42 112.81,92.42 CPU1.CN23
  BOTTOM w0.089: 115.16,92.18 115.55,91.8 119.89,91.8 120.57,91.12 127.42,91.12 127.72,91.42 v1(128.3,91.42) 128.32,91.44 R2064.2 129.8,91.31 R2063.1
VREF_CPU: length 4
  TOP w0.203: v1(39.93,73.15) 39.88,73.1 39.88,72.32 39.66,72.09 U2401.95
  TOP w0.305: R2402.2 40.82,73.32 41.07,73.06 C2406.1 40.59,72.8 40.24,73.15 v1(39.93,73.15)
VREG3PD:
  vias: v1(52.39,127.76)
WHITE_LED_BAT: length 27.8
  L5 w0.254: v2(14.4,129.49) 14.63,129.26 15.11,129.26 17.55,126.82 17.55,120.24 15.73,118.42 14.25,118.42 11.69,115.85 v2(11.69,112.09)
  BOTTOM w0.254: v2(11.69,112.09) v1(12.83,112.09) 13.11,111.81 Q6404.C ; R6406.1 13.74,129.19 EC6404.1 14.07,129.16 v2(14.4,129.49)
WIFI_RF_EN: length 234.3
  TOP w0.089: v2(30.13,34.52) 32.15,36.54 33.89,36.54 35.27,37.92 35.27,38.3 36.42,39.46 36.42,41.42 37.15,42.15 41.47,42.15 42.16,42.84 45.72,42.84 47.45,44.58 47.45,49.15 47.48,49.18 47.48,49.97 55.15,57.65 99.01,57.65 99.26,57.39 108.26,57.39 117.72,66.85 117.72,69.16 117.41,69.46 v2(117.41,70.6) ; R6109.2 42.98,101.32 AFTP6110.1 41.79,101.6 42.4,102.21 v2(43.16,102.21)
  L5 w0.089: v2(108.62,91.7) 109.23,91.09 109.45,91.09 109.61,90.92 110.28,90.92 111.86,89.34 111.86,84.81 111.16,84.11 111.16,76.86 v2(117.41,70.6)
  L6 w0.089: v2(30.13,34.52) 29.73,34.92 24.47,34.92 23.85,35.54 23.5,35.54 23.25,35.79 23.25,36.77 21.94,38.08 21.94,42.63 21.4,43.17 21.4,50.42 21.92,50.94 21.92,52.88 21.07,53.74 21.07,57.47 23.7,60.1 25.93,60.1 26.38,60.55 26.38,64.65 29.13,67.4 30.74,67.4 32.36,69.01 38,69.01 39.5,70.51 40.4,70.51 44.67,74.78 44.67,77.9 45.11,78.34 45.11,79.78 45.8,80.47 45.8,81.47 47.6,83.27 47.6,85.39 48.57,86.35 48.57,91.43 45.7,94.3 45.7,99.67 v2(43.16,102.21)
  BOTTOM w0.089: CPU1.CG25 108.62,91.62 v2(108.62,91.7)
WIFI_RF_EN_R: length 7
  TOP w0.089: v1(44.87,101.13) 44.62,101.13 44.25,101.5 R6109.1 43.69,101.93 43.69,102.45 v2(44.15,102.9) 45.14,103.89 R6114.2
  BOTTOM w0.089: WLAN1.56 44.7,103.42 44.18,102.9 v2(44.15,102.9)
WLAN_CLK_CPU_N: length 72
  L5 w0.102: v2(93.68,108) 93.53,107.85 93.34,107.85 93.21,107.98 93.21,108.82 92.81,109.22 92.81,109.55 92.18,110.19 92.18,110.9 87.3,115.77 67.55,115.77 64.6,112.83 64.01,112.83 61.61,110.42 61.61,106.79 58.96,104.14 58.96,99.54 58.68,99.26 58.14,99.26 57.99,99.11 57.99,99.06 57.8,98.87 57.62,98.87 v2(57.57,98.91)
  BOTTOM w0.114: WLAN1.49 42.95,98.25 42.68,98.52 42.68,98.81 42.83,98.96 48.87,98.96 49.81,99.9 56.17,99.9 56.75,99.32 57,99.32 57.13,99.19 57.13,98.96 57.25,98.83 57.5,98.83 v2(57.57,98.91) ; CPU1.BC1 94.18,106.65 94.18,108.01 94.01,108.17 93.81,108.17 93.68,108.04 v2(93.68,108)
WLAN_CLK_CPU_P: length 72.1
  L5 w0.102: v2(57.57,99.54) 57.65,99.47 58.59,99.47 58.75,99.63 58.75,104.23 61.41,106.88 61.41,110.51 63.93,113.03 64.52,113.03 67.47,115.98 87.39,115.98 92.38,110.98 92.38,110.27 93.02,109.64 93.02,109.31 v2(93.68,108.64)
  BOTTOM w0.114: CPU1.BC2 94.61,106.11 94.61,106.7 94.4,106.91 94.4,108.1 93.87,108.64 v2(93.68,108.64) ; v2(57.57,99.54) 56.85,99.54 56.26,100.13 49.72,100.13 48.78,99.19 42.73,99.19 42.45,98.91 WLAN1.47
WLAN_EN#: length 24.8
  TOP w0.089: R6102.2 61.53,95.15 v2(61.5,97.94) 61.55,97.99 61.55,98.83 60.81,99.57 60.81,101.7 53.92,108.59 Q6102.D
  BOTTOM w0.089: v2(61.5,97.94) v1(61.5,96.7) 61.5,95.58 59.71,93.79 U6101.4
WLAN_PCIE_RX_N10: length 86.8
  L6 w0.102: v2(57.53,98.25) 57.33,98.05 57.14,98.05 57,98.18 57,99.61 58.33,100.94 59.62,100.94 62.33,103.65 64.42,103.65 66.58,105.8 66.58,106.26 69.4,109.08 69.4,110.06 70.8,111.47 91.68,111.47 94.08,113.87 98.7,113.87 98.94,113.63 98.94,112.81 99.77,111.97 99.77,111.55 100.23,111.09 100.23,107.11 100.38,106.96 100.38,103.3 v2(100.89,102.79)
  BOTTOM w0.114: CPU1.BN6 v2(100.89,102.79) ; WLAN1.43 41.45,96.6 41.31,96.46 41.31,95.16 41.82,94.65 43.06,94.65 43.75,93.97 51.68,93.97 53.72,96.01 53.72,98.6 54.56,99.43 55.97,99.43 56.9,98.5 56.9,98.17 57.03,98.05 57.33,98.05 v2(57.53,98.25)
WLAN_PCIE_RX_P10: length 87.6
  L6 w0.102: v2(57.53,97.61) 57.31,97.84 57.06,97.84 56.8,98.1 56.8,99.69 58.25,101.14 59.54,101.14 62.25,103.85 64.33,103.85 66.37,105.89 66.37,106.35 69.19,109.17 69.19,110.15 70.72,111.67 91.6,111.67 94,114.07 98.79,114.07 99.14,113.72 99.14,112.89 99.98,112.06 99.98,111.63 100.43,111.18 100.43,107.2 100.59,107.05 100.59,103.54 100.67,103.46 v2(100.9,103.46)
  BOTTOM w0.114: WLAN1.41 40.95,96.6 41.09,96.46 41.09,95.07 41.73,94.43 42.97,94.43 43.65,93.74 51.77,93.74 53.95,95.92 53.95,98.5 54.65,99.2 55.88,99.2 56.67,98.41 56.67,98.08 56.93,97.82 57.33,97.82 v2(57.53,97.61) ; CPU1.BN5 v2(100.9,103.46)
WLAN_PCIE_TX_CON_N: length 2.3
  BOTTOM w0.114: WLAN1.37 39.95,96.6 39.81,96.46 39.81,95.66 C6107.1
WLAN_PCIE_TX_CON_P: length 2.3
  BOTTOM w0.114: C6108.1 39.59,95.7 39.59,96.46 39.45,96.6 WLAN1.35
WLAN_PCIE_TX_N10: length 85.1
  L6 w0.102: v2(100.99,110.59) 101.2,110.8 101.71,110.8 102.03,111.13 102.03,111.98 99.36,114.65 92.87,114.65 91.17,112.95 90.79,112.96 74.1,112.96 73.4,112.26 70.28,112.26 68.61,110.58 68.61,109.61 65.79,106.79 65.79,106.16 64.06,104.43 61.98,104.43 59.79,102.24 58.51,102.24 56.11,99.83 56.11,97.97 55.98,97.84 55.7,97.84 v2(55.55,97.99)
  BOTTOM w0.076: 101.44,108.48 101.44,108.47 101.47,108.44 101.47,107.01 101.23,106.77 101.23,106.35 101.24,106.32 101.26,106.27 101.26,106.05 101.23,105.97 101.23,105.67 101.24,105.66 101.38,105.34 101.38,104.81 CPU1.BR4
  BOTTOM w0.114: v2(55.55,97.99) 55.35,97.79 54.97,97.79 54.66,97.49 54.66,95.97 51.97,93.27 43.46,93.27 42.85,93.88 39.96,93.88 39.78,94.06 39.78,94.2 C6107.2 ; 101.44,108.48 101.44,110.56 101.29,110.72 101.12,110.72 v2(100.99,110.59)
WLAN_PCIE_TX_P10: length 84.6
  L6 w0.102: v2(55.55,97.36) 55.83,97.64 56.07,97.64 56.31,97.88 56.31,99.75 58.6,102.03 59.87,102.03 62.07,104.23 64.15,104.23 65.99,106.07 65.99,106.71 68.81,109.53 68.81,110.5 70.37,112.05 73.49,112.05 74.19,112.75 90.7,112.75 91.25,112.75 92.95,114.45 99.27,114.45 101.83,111.89 101.83,111.21 101.62,111.01 101.22,111.01 v2(100.99,111.23)
  BOTTOM w0.076: CPU1.BR3 101.56,105.29 101.56,105.38 101.41,105.73 101.41,105.94 101.44,106.02 101.44,106.3 101.41,106.38 101.41,106.7 101.65,106.94 101.65,108.36 101.67,108.38 101.67,108.48
  BOTTOM w0.114: 101.67,108.48 101.67,110.66 101.31,111.02 101.2,111.02 v2(100.99,111.23) ; v2(55.55,97.36) 55.35,97.56 55.06,97.56 54.89,97.39 54.89,95.87 52.06,93.04 43.36,93.04 42.75,93.65 39.86,93.65 39.55,93.96 39.55,94.23 C6108.2
WWAN_BB_RST#: length 155
  TOP w0.089: v2(178.09,61.87) 177.44,61.22 175.8,61.22 175.24,60.65 169.47,60.65 v2(169.14,60.33) 169.12,60.33 168.74,60.71 v1(168.71,60.71) ; WWAN1.16 216.93,53.05 216.26,53.72 216.26,54.49 215.27,55.48 v2(215.27,56.54)
  L3 w0.089: v2(108.7,96.94) 109.28,97.52 113.23,97.52 114.45,98.73 119.7,98.73 119.76,98.79 120.59,98.79 120.94,98.45 120.94,98.31 122.44,96.81 122.44,92.81 123.14,92.1 123.14,89.82 122.48,89.16 122.32,89.16 121.71,88.55 v2(121.71,87.29)
  L5 w0.089: v2(169.14,60.33) 169.14,61.12 167.37,62.89 165.05,62.89 164.4,63.55 158.32,63.55 158.19,63.42 130.64,63.42 125.58,68.48 125.12,68.48 119.53,74.07 119.53,74.26 119.53,79.54 122.23,82.24 122.23,86.77 v2(121.71,87.29)
  L6 w0.089: v2(215.27,56.54) 214.81,56.54 214.48,56.87 214.48,57.51 214.02,57.97 212.43,57.97 211.18,56.72 211.18,56.53 210.79,56.14 199.57,56.14 199.11,56.6 196.25,56.6 195.72,57.13 191.49,57.13 190.96,56.6 182.06,56.6 177.7,60.96 177.7,61.47 v2(178.09,61.87)
  BOTTOM w0.089: CPU1.CF17 108.36,96.59 v2(108.7,96.94)
WWAN_CLKREQ_CPU_N: length 154.9
  TOP w0.089: R1825.2 151.29,69.58 154.89,65.98 154.89,63.3 v1(155.24,62.95) v2(157.79,60.41) ; v2(169.29,57.74) 169.29,58.16 171.23,60.1 175.45,60.1 175.96,60.61 182.59,60.61 182.89,60.31 188.08,60.31 192.4,64.63 192.4,65.65 192.53,65.78 200.32,65.78 201.55,64.55 210.96,64.55 211.6,63.91 211.6,62.45 213.24,60.81 213.24,60.58 213.24,60.58 213.24,60.07 215.87,57.44 216.08,57.23 216.08,55.44 216.48,55.05 WWAN1.20
  L5 w0.089: v2(169.29,57.74) 169.29,58.27 167.27,60.29 157.91,60.29 v2(157.79,60.41) 157.36,59.98 126.65,59.98 121.1,65.53 121.1,66.31 109.76,77.66 109.76,86.13 109.77,86.14 109.77,86.49 109.45,86.8 109.45,87.48 v2(109.02,87.91)
  BOTTOM w0.089: CPU1.CF31 v2(109.02,87.91)
WWAN_DB_DET#: length 270.7
  TOP w0.089: R6201.1 204.6,62.92 203.36,64.16 201.07,64.16 199.81,65.43 194.79,65.43 v2(194.36,65) ; v2(13.52,63.96) 14.41,63.07 14.41,60.63 17.94,57.1 R2403.2 ; v2(134.04,73.2) 134.09,73.25 134.09,76.14 133.78,76.45 132.46,76.45
  L5 w0.089: v2(61.09,98.5) 61.95,98.5 62.21,98.25 62.21,97.59 62.57,97.23 65.22,97.23 65.92,97.92 65.92,98.14 67.41,99.64 67.56,99.64 69.15,99.64 69.24,99.55 73.99,99.55 74.14,99.4 86.14,99.4 86.34,99.59 96.67,99.59 97.72,98.55 97.72,95.65 100.84,92.53 100.84,92.24 101.21,91.87 102.94,91.87 103.79,91.02 104.13,91.02 104.13,91.03 105.07,91.03 105.08,91.02 109.03,91.02 109.15,90.9 109.26,90.9 109.58,90.58 110.09,90.58 110.79,89.88 111.08,89.88 111.66,89.29 111.66,84.93 110.96,84.23 110.96,82.12 v2(110.18,81.34) ; v2(134.04,73.2) 134.72,73.89 158.3,73.89 158.36,73.95 160.15,73.95 161.16,72.94 161.45,72.94 161.58,72.81 166.31,72.81 167.31,71.81 174.15,71.81 174.37,71.58 175.88,71.58 178.32,69.14 179.21,69.14 182.14,66.22 182.14,64.9 184.5,62.55 188.08,62.55 189.54,64.02 194.14,64.02 194.36,64.24 v2(194.36,65)
  BOTTOM w0.076: CPU1.CH36 109.51,84.27 109.7,84.08 109.78,83.95 109.78,82.86 109.78,82.86
  BOTTOM w0.089: v2(61.09,98.5) 60.57,98.5 v1(60.1,98.03) 59.91,98.03 58.33,96.45 57.16,96.45 53.14,92.42 53.14,91.34 54.08,90.4 54.08,88.24 53.5,87.65 53.5,76.1 51.69,74.3 50.8,74.3 50.49,73.98 49.52,73.98 49.31,74.19 46.96,74.19 46.56,73.78 37.23,73.78 36.86,73.41 35.37,73.41 34.94,72.97 34.92,72.97 34.72,72.77 32.24,72.77 31.02,71.55 31.02,69.84 30.6,69.42 30.6,69.42 30.08,68.91 30.08,68.88 28.79,67.59 25.11,67.59 24.5,66.99 22.58,66.99 22.26,67.31 20.14,67.31 20.09,67.26 19.56,66.73 18.22,66.73 18.11,66.62 18.11,66.62 17.32,65.83 15.39,65.83 v2(13.52,63.96) ; 109.78,82.86 109.78,82.79 109.78,81.74 110.18,81.34 v2(110.18,81.34) 110.18,80.55 110.29,80.44 110.29,77.92 113.38,74.83 118.55,74.83 120.52,72.87 120.52,72.86 121.12,72.27 123.83,72.27 125.33,73.76 133.48,73.76 v2(134.04,73.2)
WWAN_DB_DET#_R: length 19.7
  TOP w0.089: R6201.2 205.92,63.63 v1(206.1,63.81) 206.48,64.19 210.81,64.19 211.23,63.78 211.23,62.26 212.88,60.61 212.88,60.44 212.88,60.43 212.88,59.93 215.73,57.09 215.73,55.3 216.54,54.48 216.54,54.03 217.02,53.55 WWAN1.17
WWAN_FULL_PWR_EN: length 15.3
  BOTTOM w0.076: CPU1.CM23 112.45,92.9 112.69,92.9 112.76,92.88 113.05,92.88 113.14,92.9 113.26,92.91 113.48,92.88 113.78,92.88 113.95,92.99 114.04,93.09 114.36,93.09 114.59,92.86 114.71,92.76 114.81,92.69
  BOTTOM w0.089: 114.81,92.69 115.04,92.58 115.64,91.98 119.96,91.98 120.65,91.3 125.13,91.3 v1(125.38,91.54) R2051.1
WWAN_FULL_PWR_EN_D8: length 17.4
  BOTTOM w0.076: CPU1.CJ22 110.87,93.6 112.04,93.6 112.5,93.42 112.58,93.3 112.61,93.2 112.72,93.07 112.79,93.04 113.01,93.04 113.13,93.08 113.28,93.08 113.49,93.04 113.64,93.04 113.76,93.06 113.85,93.14 113.97,93.25 114.43,93.25 114.69,93 114.72,92.97 114.74,92.95 114.96,92.86
  BOTTOM w0.089: 114.96,92.86 115.01,92.86 115.71,92.17 120.03,92.17 120.52,91.67 v1(122.79,91.67) 123.23,91.67 123.42,91.47 124.44,91.47 124.87,91.9 125.61,91.9 126.01,92.3 R2067.1
WWAN_FULL_PWR_EN_R: length 141.3
  TOP w0.089: v2(190.94,65) 190.94,64.18 187.78,61.02 183.19,61.02 180.51,63.7 180.51,66.79 176.18,71.12 176.18,71.91 176.01,72.08 v1(176.01,72.19) 176.01,72.77 173.33,75.44 172.29,75.44 v2(172.22,75.36) ; v2(218.37,62.59) 218.54,62.59 219.04,62.1 219.06,62.1 219.13,62.03 220.48,62.03 220.98,61.52 220.98,54.74 218.93,52.68 218.93,49.38 218.6,49.05 WWAN1.8
  L6 w0.089: v2(218.37,62.59) 217.15,63.81 216.72,63.81 v2(215.5,65.03) ; v2(133.02,91.42) 132.97,91.36 132.97,87.04 133.18,86.83 133.56,86.45 133.56,79.53 136.24,76.84 139.71,76.84 142.46,76.84 143.36,75.94 155.57,75.94 156.59,76.96 156.94,76.96 157.11,76.79 161.75,76.79 163.26,75.28 163.51,75.03 164.24,75.03 164.62,74.66 v2(164.62,74.02)
  BOTTOM w0.089: v2(164.62,74.02) 165.18,74.02 167.47,71.73 170.35,71.73 172.22,73.6 v2(172.22,75.36) ; v2(190.94,65) 192.08,66.14 214.38,66.14 v2(215.5,65.03) ; v2(133.02,91.42) 132.93,91.51 132.93,91.74 132.68,91.99 132.62,91.99 132.62,92 129.09,92 128.86,91.78 127.52,91.78 127.28,91.54 R2051.2 R2067.2
WWAN_GPIO_PERST#: length 143.4
  TOP w0.089: v2(178.13,61.23) 177.9,61.23 177.65,60.99 175.82,60.99 175.29,60.45 170.2,60.45 169.39,59.64 168.12,59.64 v1(168.11,59.64) 168.07,59.68 v2(168.07,60.76) ; v2(215.06,57.14) 214.84,56.92 214.84,55.86 215.09,55.61 215.09,55.41 216.08,54.42 216.08,53.57 217.1,52.55 WWAN1.15
  L5 w0.089: v2(109.32,92.68) 109.82,92.18 110.82,92.18 111.29,91.71 111.9,91.71 113.69,89.92 113.69,84.19 113.79,84.09 113.79,79.7 113.69,79.6 113.69,76.13 122.67,67.15 122.67,65.43 126.46,61.63 159.28,61.63 159.76,61.15 165.62,61.15 166.16,61.69 167.82,61.69 168.07,61.44 v2(168.07,60.76)
  L6 w0.089: v2(178.13,61.23) 178.13,61.07 182.42,56.78 190.89,56.78 191.42,57.3 195.79,57.3 196.32,56.78 199.19,56.78 199.64,56.32 210.71,56.32 211,56.61 211,57.65 211,57.92 212.44,59.36 213.16,59.36 215.06,57.46 215.06,57.15 v2(215.06,57.14)
  BOTTOM w0.089: CPU1.CH22 109.66,93.01 v2(109.32,92.68)
WWAN_PCIE_CLK_N: length 195.7
  TOP w0.114: v2(219.92,58.94) 219.8,58.82 219.8,58.38 219.53,58.12 218.32,58.12 218.26,58.05 WWAN1.26
  L6 w0.102: v2(219.92,58.94) 219.81,59.04 219.81,59.6 219.31,60.1 217.89,60.1 217.54,60.45 211.64,60.45 211,59.82 200.23,59.82 199.21,60.83 191.21,60.83 189.76,59.39 184.22,59.39 179.87,63.74 179.87,65.19 176.79,68.26 173.28,68.26 173.09,68.45 171.88,68.45 171.35,68.99 161.42,68.99 159.59,70.82 131.55,70.82 129.64,72.72 128.51,72.72 126.71,74.52 126.71,80.02 126.93,80.23 126.93,95.58 126.44,96.06 126.44,104.33 125.97,104.81 125.97,109.18 122.99,112.16 122.99,115.32 121.36,116.95 121.36,118.66 116.67,123.34 113.47,123.34 113.24,123.57 v2(113.23,123.57)
  BOTTOM w0.076: 95.15,108.38 95.15,108.36 95.18,108.33 95.18,107.47 95.55,107.1 95.55,106.57 CPU1.BE1
  BOTTOM w0.114: 95.15,108.38 95.15,110.04 94.33,110.87 94.33,111.47 93.79,112 93.79,115.84 95.33,117.37 97.01,117.37 97.72,118.09 97.72,119.46 99.02,120.76 107.07,120.76 108.97,122.66 111.94,122.66 112.75,123.47 113.13,123.47 v2(113.23,123.57)
WWAN_PCIE_CLK_P: length 195.6
  TOP w0.114: v2(219.28,58.94) 219.57,58.66 219.57,58.48 219.44,58.35 218.46,58.35 218.26,58.55 WWAN1.27
  L6 w0.102: v2(219.28,58.94) 219.61,59.27 219.61,59.51 219.23,59.89 217.81,59.89 217.45,60.25 211.72,60.25 211.09,59.62 200.15,59.62 199.13,60.63 191.29,60.63 189.84,59.18 184.14,59.18 179.66,63.66 179.66,65.1 176.7,68.06 173.19,68.06 173,68.25 171.8,68.25 171.27,68.78 161.34,68.78 159.51,70.61 131.47,70.61 129.56,72.52 128.43,72.52 126.51,74.44 126.51,80.1 126.72,80.32 126.72,95.5 126.24,95.98 126.24,104.25 125.76,104.72 125.76,109.1 122.79,112.08 122.79,115.23 121.16,116.86 121.16,118.57 116.59,123.14 113.44,123.14 v2(113.24,122.94)
  BOTTOM w0.076: CPU1.BE2 95.46,106.08 95.72,106.34 95.72,107.18 95.35,107.54 95.35,108.33 95.38,108.36 95.38,108.38
  BOTTOM w0.114: 95.38,108.38 95.38,110.14 94.55,110.96 94.55,111.56 94.02,112.1 94.02,115.75 95.42,117.15 97.1,117.15 97.95,117.99 97.95,119.36 99.12,120.53 107.17,120.53 109.06,122.43 112.04,122.43 112.85,123.24 112.93,123.24 v2(113.24,122.94)
WWAN_PCIE_RX_N: length 173.9
  TOP w0.114: v2(219.81,60.65) 219.81,60 219.4,59.59 218.24,59.59 218.2,59.55 WWAN1.29
  L5 w0.102: v2(219.81,60.65) 219.71,60.75 219.71,60.75 219.72,60.75 219.72,61.24 219.33,61.63 218.69,61.63 217.91,62.41 200.23,62.41 198.76,60.94 190.89,60.94 189.26,59.31 183.36,59.31 180.01,62.66 180.01,62.68 178.92,63.78 178.92,64.39 175.72,67.59 174.09,67.59 172.75,67.59 171.44,68.9 161.36,68.9 161.22,69.04 132.32,69.04 127.05,74.3 127.05,94.75 125.28,96.53 125.28,102.9 123.24,104.93 123.24,109.82 121.36,111.71 119.06,111.71 115.94,114.83 108.36,114.83 108.18,115.01 107.59,115.01 107.11,114.54 107.11,105.2 105.92,104.01 105.92,102.23 105.85,102.16 v2(105.57,102.16)
  BOTTOM w0.114: v2(105.57,102.16) 105.49,102.16 CPU1.BY8
WWAN_PCIE_RX_P: length 173.9
  TOP w0.114: WWAN1.30 218.16,60.05 218.39,59.82 219.31,59.82 219.59,60.1 219.59,60.25 219.19,60.65 v2(219.18,60.65)
  L5 w0.102: v2(219.18,60.65) 219.2,60.65 219.51,60.96 219.51,61.16 219.24,61.43 218.6,61.43 217.83,62.21 200.32,62.21 198.84,60.73 190.97,60.73 189.35,59.11 183.28,59.11 179.81,62.58 179.81,62.6 178.72,63.69 178.72,64.3 175.63,67.39 174.18,67.39 172.66,67.39 171.36,68.69 161.28,68.69 161.13,68.84 132.24,68.84 126.85,74.22 126.85,94.67 125.07,96.44 125.07,102.81 123.04,104.84 123.04,109.74 121.27,111.51 118.98,111.51 115.86,114.63 108.28,114.63 108.1,114.81 107.67,114.81 107.32,114.45 107.32,105.12 106.12,103.92 106.12,102.14 105.5,101.52 v2(105.5,101.51)
  BOTTOM w0.114: v2(105.5,101.51) 105.32,101.53 105.12,101.37 CPU1.BY9
WWAN_PCIE_TX_N: length 164.6
  TOP w0.114: v2(212.69,62.84) 212.94,62.59 212.94,61.95 213.71,61.18 214.44,61.18 C6201.1
  L5 w0.102: v2(106.15,111.36) 106.05,111.25 105.84,111.25 105.72,111.38 105.72,114.17 106.96,115.42 108.38,115.42 108.55,115.24 116.86,115.24 118.81,113.29 120.6,113.29 124.11,109.79 124.11,105.26 125.61,103.76 125.91,103.45 125.91,96.47 127.46,94.92 127.46,86.51 128.04,85.93 128.04,73.9 131.84,70.1 163.41,70.1 164.21,69.3 171.61,69.3 172.92,68 173.92,68 173.93,68 174.31,68.38 175.3,68.38 175.68,68 175.88,68 179.33,64.55 179.33,64.13 183.61,59.84 189.09,59.84 190.59,61.34 198.54,61.34 200.63,63.43 212.7,63.43 212.9,63.23 212.9,63.05 v2(212.69,62.84)
  BOTTOM w0.076: CPU1.CA2 105.23,106.08 104.95,106.36 104.95,107.59 105.25,107.9 105.25,108.08 105.23,108.11 105.23,108.12
  BOTTOM w0.114: 105.23,108.12 105.23,110.63 105.69,111.1 105.96,111.1 106.15,111.29 v2(106.15,111.36)
WWAN_PCIE_TX_N_C: length 2.5
  TOP w0.114: WWAN1.32 217.14,61.05 217.01,61.19 216.19,61.19 216.01,61.37 215.67,61.37 C6201.2
WWAN_PCIE_TX_P: length 164.6
  TOP w0.114: C6202.1 214.51,61.79 214.12,61.41 213.81,61.41 213.17,62.05 213.17,62.68 v2(213.33,62.84)
  L5 w0.102: v2(213.33,62.84) 213.1,63.06 213.1,63.31 212.79,63.63 200.54,63.63 198.46,61.55 190.5,61.55 189,60.05 183.7,60.05 179.53,64.21 179.53,64.64 175.97,68.2 175.76,68.2 175.38,68.58 174.22,68.58 173.84,68.2 173,68.2 171.7,69.5 164.29,69.5 163.5,70.3 131.93,70.3 128.24,73.99 128.24,86.01 127.66,86.59 127.66,95 126.11,96.55 126.11,103.54 125.81,103.84 124.31,105.34 124.31,109.87 120.69,113.5 118.9,113.5 116.95,115.44 108.64,115.44 108.46,115.62 106.88,115.62 105.51,114.26 105.51,111.3 105.76,111.05 105.76,111.05 106.15,110.66 v2(106.15,110.57)
  BOTTOM w0.076: 105.45,108.12 105.45,108.11 105.43,108.08 105.43,107.82 105.12,107.52 105.12,106.56 105.2,106.48 CPU1.CA1
  BOTTOM w0.114: 105.45,108.12 105.45,110.54 105.79,110.87 106.04,110.87 106.15,110.76 v2(106.15,110.57)
WWAN_PCIE_TX_P_C: length 2.5
  TOP w0.114: WWAN1.33 217.14,61.55 217.01,61.41 216.29,61.41 216.1,61.6 215.71,61.6 C6202.2
WWAN_PCIE_WAKE_N: length 1.3
  TOP w0.089: TP6201.1 216.51,55.55 WWAN1.21
WWAN_USB20_N: length 148.9
  TOP w0.114: R6203.1 215.8,59.23 215.67,59.36 214.79,59.36 ; 214.79,59.36 214.6,59.36 214.2,59.76 v2(214.2,59.82) ; 214.79,59.36 v1(214.79,59.21)
  L5 w0.102: v2(214.2,59.82) 214.1,59.92 209.68,59.92 207.57,57.81 206.66,57.81 205.08,56.24 199.27,56.24 199.01,56.49 196.19,56.49 195.66,57.02 191.57,57.02 190.78,56.24 181.47,56.24 178.55,59.16 175.67,59.16 173.79,61.04 173.79,63.76 173.41,64.14 170.76,64.14 170.31,64.58 170.31,64.96 169.79,65.48 156.77,65.48 156.57,65.28 155.71,65.28 155.2,65.79 130.51,65.79 123.98,72.32 123.98,90.07 122.76,91.29 122.76,93.53 120.77,95.52 120.77,96.05 119.84,96.99 119.84,98.89 119.64,99.09 119.64,100.23 117.53,102.34 113.91,102.34 112.59,101.02 107.14,101.02 106.99,101.17 106.99,101.56 106.87,101.69 106.72,101.69 v2(106.53,101.5)
  BOTTOM w0.114: CPU1.CB8 106.02,101.63 106.15,101.5 v2(106.53,101.5)
WWAN_USB20_N_R: length 3.1
  TOP w0.114: R6203.2 215.8,58.17 216.54,57.43 216.56,57.41 ; 216.56,57.41 216.61,57.35 216.61,56.8 216.86,56.55 WWAN1.23 ; 216.56,57.41 v1(216.46,57.3)
WWAN_USB20_P: length 149.4
  TOP w0.114: v2(106.58,100.81) 106.74,100.97 v1(107.12,100.97) ; v2(214.84,59.82) 215.33,59.59 215.82,59.59 216.18,59.47 R6202.1
  L5 w0.102: v2(106.58,100.81) 107.14,100.81 107.14,100.82 112.68,100.82 114,102.14 117.44,102.14 119.43,100.15 119.43,99.01 119.64,98.81 119.64,96.9 120.57,95.97 120.57,95.44 122.56,93.45 122.56,91.2 123.78,89.99 123.78,72.23 130.43,65.58 155.12,65.58 155.63,65.08 156.65,65.08 156.86,65.28 169.7,65.28 170.11,64.87 170.11,64.5 170.67,63.93 173.32,63.93 173.59,63.67 173.59,60.95 175.59,58.95 178.46,58.95 181.38,56.03 190.86,56.03 191.65,56.82 195.57,56.82 196.11,56.29 198.93,56.29 199.18,56.03 205.17,56.03 206.74,57.61 207.66,57.61 209.76,59.72 213.69,59.72 214.02,59.39 214.4,59.39 v2(214.84,59.82)
  BOTTOM w0.114: CPU1.CB9 v2(106.58,100.81)
WWAN_USB20_P_R: length 2.9
  TOP w0.114: R6202.2 216.41,58.06 216.41,57.88 216.64,57.66 216.92,57.66 217.05,57.53 217.05,57.33 216.84,57.13 216.84,56.89 216.95,56.78 217.1,56.78 217.38,57.05 WWAN1.24
XCLK_BIASREF: length 12.2
  BOTTOM w0.076: 111.61,108.19 110.98,108.19 109.91,107.11 109.91,106.69 CPU1.CJ1
  BOTTOM w0.127: v1(115.32,114.91) 115.71,114.53 R1803.1 116.18,112.55 113.62,109.98 113.41,109.98 111.61,108.19
XDP_CLK_CPU_N: length 3
  BOTTOM w0.114: CPU1.AU1 90.48,106.59 90.48,108.96 TP1808.1
XDP_CLK_CPU_P: length 5.1
  BOTTOM w0.114: CPU1.AU2 90.25,106.17 90.25,109.92 TP1807.1
XDP_DBRESET#: length 7.2
  BOTTOM w0.076: CPU1.CN10 112.59,100.78 112.9,100.47 113.35,100.47 113.41,100.45 114.93,100.45 114.96,100.41 115.03,100.41 115.24,100.2
  BOTTOM w0.114: R1701.2 119.15,100.21 117.56,100.21 v1(117.55,100.2) 115.24,100.2
XDP_PRDY#: length 4.8
  BOTTOM w0.114: TP9107.1 77.05,109.06 78.48,109.06 79.69,107.85 CPU1.W1
XDP_PREQ#: length 6.6
  BOTTOM w0.114: CPU1.W2 79.69,105.9 79.97,106.18 79.97,107.86 78.54,109.29 77.71,109.29 76.84,110.16 TP9106.1
XDP_TCK_JTAGX: length 3.5
  TOP w0.114: v1(75.49,103.96) 76.05,104.52 R315.1 76.43,104.37 76.43,103.28 v2(76.89,102.82)
  BOTTOM w0.114: CPU1.P6 v2(76.89,102.82)
XDP_TCLK: length 14
  TOP w0.114: v2(67,101.52) v1(67.56,101.52)
  L6 w0.114: v2(77.82,102.82) 77.16,102.09 76.6,101.53 74.43,101.53 74.02,101.93 67.41,101.93 v2(67,101.52)
  BOTTOM w0.114: v2(67,101.52) 66.67,101.52 R317.1 ; CPU1.T6 v2(77.82,102.82)
XDP_TDI: length 2.6
  TOP w0.114: v2(78.74,102.82) 78.41,103.15 v1(78.41,103.33) 78.41,103.76 77.8,104.37 R311.1
  BOTTOM w0.114: CPU1.U6 v2(78.74,102.82)
XDP_TDO_CPU: length 3.1
  TOP w0.114: v1(81.21,104.07) 81.21,103.94 v2(80.62,103.36) 79.89,104.09 R310.1
  BOTTOM w0.114: CPU1.Y5 80.19,103.79 v2(80.62,103.36)
XDP_TMS: length 2.3
  TOP w0.114: v2(77.82,103.47) 77.24,103.47 v1(77.06,103.66) 77.04,103.67 R309.1
  BOTTOM w0.114: CPU1.T5 v2(77.82,103.47)
XDP_TRST#: length 10.6
  TOP w0.114: v2(80.62,102.71) 80.8,102.71 v1(81.1,102.41)
  L6 w0.114: v2(80.62,102.71) 81.1,103.19 81.1,104.46 81,104.56 81,105.35 81.01,105.36 81.01,107.37 81.43,107.79 v2(81.43,107.8)
  BOTTOM w0.114: R316.1 81.03,110.16 81.59,109.6 81.59,108.84 81.44,108.69 81.44,107.81 v2(81.43,107.8) ; CPU1.AB6 80.73,102.82 v2(80.62,102.71) 80.52,102.81 CPU1.Y6
XTL_24M_X1_CPU: length 14.7
  BOTTOM w0.076: CPU1.CK3 111.07,105.85 111.02,105.9 111.02,106.19 111.51,106.68 111.51,107.16 111.76,107.42 112.27,107.42
  BOTTOM w0.114: 112.27,107.42 113.39,108.54 114.96,108.54 114.98,108.55 114.98,108.55 119.5,113.07 119.5,113.07 120.6,114.17 R1839.1
XTL_24M_X1_R: length 3
  BOTTOM w0.114: X1801.1 119.08,116.22 R1841.1 119.1,115.32 C1807.2 R1839.2
XTL_24M_X2_CPU: length 13.8
  BOTTOM w0.076: 112.04,107.7 111.32,107.7 110.72,107.1 110.72,106.8 110.52,106.6 110.52,106.37 110.8,106.1 CPU1.CK2
  BOTTOM w0.114: R1840.1 119.03,113.26 114.79,109.02 113.36,109.02 112.04,107.7
XTL_24M_X2_R: length 5
  BOTTOM w0.114: R1840.2 118.14,114.56 C1808.2 118.16,115.29 R1841.2 117.4,116.16 117.4,117.01 X1801.3
XTL_32K_X1_CPU: length 30.7
  TOP w0.114: X1802.1 121.57,75.13 C1804.1 120.25,75.13 R1815.1 119.21,76.18 v2(118.75,76.18)
  L3 w0.089: v2(100.76,87.17) 100.46,86.87 100.46,86.32 102.04,84.74 103.82,84.74 103.97,84.59 105.23,84.59 107.01,82.81 109.15,82.81 110.06,83.72 113.74,83.72 115.85,81.62 115.85,78.53 118.06,76.32 118.61,76.32 v2(118.75,76.18)
  BOTTOM w0.114: CPU1.BN31 100.72,87.32 v2(100.76,87.17)
XTL_32K_X2_CPU: length 28.7
  TOP w0.114: v2(118.75,76.81) 118.91,76.65 119.4,76.65 119.77,76.28 R1815.2 C1803.1 120.93,76.46 121.59,76.46 X1802.2
  L3 w0.089: v2(118.75,76.81) 118.62,76.68 118.21,76.68 116.23,78.67 116.23,81.75 113.88,84.1 109.83,84.1 109.53,83.8 109.51,83.8 109.49,83.77 106.61,83.77 105.42,84.96 104.13,84.96 103.97,85.11 102.23,85.11 v2(100.86,86.49)
  BOTTOM w0.114: v2(100.86,86.49) 100.81,86.49 100.4,86.7 CPU1.BN32
XVDD_R1: length 1.8
  TOP w0.305: v1(125.92,128.98) 125.92,128.99 v2(125.92,129.57)
  TOP w0.508: R8001.2 125.58,129.59 125.9,129.59 v2(125.92,129.57)
  BOTTOM w0.305: GPU1.V5 v2(125.92,129.57)
XVDD_R2: length 1.8
  TOP w0.305: v2(126.52,130.16) 126.86,130.51 v1(126.86,130.6)
  TOP w0.508: R8002.2 126.13,130.16 v2(126.52,130.16)
  BOTTOM w0.305: GPU1.V6 v2(126.52,130.16)
N92950396: length 14.3
  TOP w0.089: Q2510.G 158.34,90.91 158.5,91.06 160.3,91.06 161.05,91.81 161.05,92.59 161.28,92.82 162.57,92.82 163.27,93.52 164.34,93.52 164.85,93.02 165.89,93.02 v1(166.22,92.69) 166.7,92.21 R2567.2 165.94,91.83 C2517.1 165.72,91.86 164.97,91.1 D2502.A

## Copper pours and planes (outline as drawn)
1V_CPU_CORE on TOP: 88.01,89.46 87.89,89.59 87.89,90.43 86.82,91.49 86.82,91.67 85.52,92.97 84.76,92.97 84.38,93.35 84.38,96.85 84.25,96.98 82.98,96.98 82.76,97.21 82.76,98.12 82.88,98.25 86.06,98.25 86.08,98.27 86.08,98.53 86.36,98.53 86.52,98.68 86.52,102.52 86.39,102.64 86.39,104.47 86.77,104.85 86.77,106.88 85.4,108.26 80.19,108.26 77.09,111.35 77.09,114.35 77.73,114.99 77.73,122.48 77.22,122.99 73.66,122.99 73.16,123.5 73.16,126.67 73.82,127.33 85.73,127.33 85.84,127.45 85.86,127.43 87,127.43 87.25,127.18 87.25,126.8 87.13,126.67 86.62,126.67 86.39,126.44 86.39,118.59 86.72,118.26 88.19,118.26 88.32,118.14 88.32,114.83 88.88,114.28 91.34,114.28 94.53,111.09 94.53,108.34 95.89,106.99 96.27,106.99 96.4,106.86 96.4,106.38 96.19,106.17 95.68,106.17 94.62,105.11 94.62,103.61 94.82,103.4 94.82,101.07 95.51,100.38 95.51,100.1 95.25,99.85 94.34,99.85 94.16,99.67 94.16,92.64 93.6,92.08 93.6,91.52 93.88,91.24 95.1,91.24 95.43,90.91 95.43,90.17 95.56,90.04 96.37,90.04 96.52,89.89 96.52,89.59 96.4,89.46 ; 61 cut-outs
1V_CPU_CORE on BOTTOM: 74.48,119.81 74.07,120.22 74.07,122.63 73.28,123.42 73.28,127.05 73.41,127.18 75.44,127.18 75.95,126.67 77.35,126.67 78.11,127.43 83.57,127.43 83.82,127.18 83.82,126.8 83.95,126.67 84.97,126.67 85.73,127.43 87.13,127.43 87.38,127.18 87.38,124.39 85.6,122.61 85.6,120.96 84.46,119.81
1V_CPU_CORE on BOTTOM: 88.14,99.75 87.89,100 87.89,102.67 89.54,104.32 94.62,104.32 95.13,103.81 95.13,102.54 95.25,102.41 95.51,102.41 95.63,102.29 95.63,101.65 95.76,101.53 96.4,101.53 96.47,101.45 96.47,101.27 96.32,101.12 95.76,101.12 95.51,100.86 95.51,99.98 95.28,99.75
1V_CPU_CORE on BOTTOM: 87.96,89.59 87.79,89.76 87.79,91.77 88.12,92.1 96.85,92.1 96.93,92.03 96.93,90.04 96.47,89.59
1V_CPU_CORE on L2GND: 85.68,92.7 85.54,92.84 85.54,96.87 85.79,97.13 85.79,99.29 86.93,100.43 86.93,103.73 87.19,103.99 87.19,107.19 85.93,108.45 79.33,108.45 79.06,108.72 79.06,109.86 77.03,111.89 77.03,114.3 76.39,114.94 76.39,118.5 75.9,118.99 74.63,118.99 73.47,120.15 73.47,123.58 73.35,123.7 73.35,127.26 73.3,127.31 73.49,127.5 86.92,127.5 87.19,127.23 87.19,126.62 86.43,125.86 86.43,118.59 86.79,118.23 88.19,118.23 88.33,118.08 88.33,114.91 88.95,114.29 90.6,114.29 92.51,112.38 93.27,112.38 94.55,111.1 94.55,107.16 95.57,106.15 95.57,101.35 95.32,101.1 95.32,99.19 94.81,98.68 94.81,93.35 94.16,92.7
1V_CPU_CORE on L3: 87.18,127.26 87.18,126.65 86.34,125.81 86.34,118.59 86.77,118.16 88.17,118.16 88.29,118.04 88.29,114.83 88.9,114.23 90.55,114.23 92.46,112.32 93.25,112.32 94.54,111.02 94.54,108.56 96.37,106.73 96.37,106.58 95.56,105.77 95.56,101.35 95.3,101.09 95.3,93.73 95.51,93.52 95.51,91.11 96.52,90.1 96.52,89.59 96.4,89.46 87.63,89.46 85.35,91.75 85.35,97.38 87.23,99.26 87.23,102.08 87.84,102.69 87.84,104.04 87.2,104.67 87.2,107.24 86.24,108.21 79.3,108.21 79.07,108.43 79.07,109.86 77.09,111.84 77.09,114.33 76.43,114.99 76.43,118.49 75.92,119 74.65,119 73.49,120.17 73.49,123.47 73.23,123.72 73.23,127.18 73.51,127.46 86.97,127.46
1V_GT_CORE on TOP: 80.93,98.22 80.93,99.47 80.65,99.47 80.65,99.85 80.6,99.9 80.04,99.9 79.71,100.23 79.71,100.26 79.34,100.62 79.14,100.62 79,100.76 79,102.01 78.72,102.01 78.72,102.31 78.77,102.36 81.61,102.36 81.89,102.64 81.89,104.27 80.27,105.89 79.26,105.89 78.78,106.38 78.78,107.33 79.02,107.57 85.68,107.57 86.45,106.8 86.45,105.55 85.98,105.08 85.98,103.13 86.11,103 86.11,101.09 86.16,101.04 86.36,101.04 86.36,98.68 86.34,98.65 83.09,98.65 83.09,98.38 82.65,98.38 82.5,98.22
1V_GT_CORE on BOTTOM: 80.22,100.05 79.94,100.33 79.94,102.01 80.29,102.36 87.35,102.36 87.79,101.93 87.79,100.13 87.71,100.05
1V_GT_CORE on L2GND: 79.46,99.56 78.93,100.08 78.93,102.08 79.31,102.46 79.31,104.4 78.43,105.29 78.43,107.92 78.57,108.07 85.78,108.07 86.81,107.03 86.81,104.14 86.55,103.89 86.55,100.59 85.52,99.56
1V_GT_CORE on L3: 78.62,107.75 85.98,107.75 86.74,106.99 86.74,100.64 85.98,99.87 79.82,99.87 79.57,100.13 79.57,100.19 78.24,101.53 78.24,107.37
1V_VCCGT on TOP: 75.11,92.33 74.82,92.62 63.16,92.62 61.7,94.08 61.7,103.33 61.24,103.79 61.24,104.52 61.32,104.6 61.32,111.74 63.63,114.05 63.63,126.39 63.64,126.4 63.64,127.06 63.88,127.31 63.91,127.31 64.37,127.76 67.16,127.76 67.62,127.31 71,127.31 71.12,127.18 71.12,121.85 74.6,118.37 74.6,115.32 75.95,113.97 75.95,112.17 78.11,110.01 78.11,106 77.96,105.84 75.26,105.84 75.14,105.72 75.14,103.66 75.75,103.05 76.15,103.05 76.79,102.41 78.49,102.41 78.59,102.31 78.59,101.07 78.82,101.07 78.84,101.04 78.84,100.74 79.81,99.77 80.04,99.77 80.34,99.47 80.34,98.22 78.95,98.22 78.79,98.38 78.79,99.01 78.57,99.24 74.02,99.24 73.89,99.11 73.89,96.27 74.3,95.86 82.2,95.86 82.38,95.68 82.38,92.58 82.12,92.33 ; 53 cut-outs
1V_VCCGT on BOTTOM: 67.49,94.62 67.19,94.92 65.92,94.92 65.54,95.3 65.54,99.49 65.79,99.75 66.55,99.75 66.68,99.87 66.68,105.59 67.24,106.15 70.06,106.15 70.36,105.84 70.36,105.56 71.15,104.78 71.45,104.78 71.63,104.6 71.99,104.6 72.22,104.37 73.31,104.37 73.49,104.19 73.49,103.07 73.56,103 76.13,103 76.23,102.9 76.23,102.29 76.52,101.99 79.42,101.99 79.86,101.55 79.86,101.3 79.76,101.19 79.02,101.19 78.84,101.02 78.84,100.26 78.67,100.08 75.09,100.08 75.09,95.12 74.58,94.62
1V_VCCGT on BOTTOM: 66.02,119.56 65.64,119.94 65.64,122.73 65.54,122.84 65.54,122.86 64.65,123.75 64.14,123.75 63.88,124 63.88,127.18 64.37,127.66 65.81,127.66 66.68,126.8 68.96,126.8 69.29,127.13 70.79,127.13 71.28,126.65 71.28,123.9 71.3,123.88 71.3,120.17 70.69,119.56
1V_VCCGT on L2GND: 82.63,92.95 82.25,93.33 75.52,93.33 74.38,94.48 71.68,94.48 71.04,93.84 64.85,93.84 64.33,94.37 64.33,105.13 65.6,106.4 65.6,109.96 66.11,110.46 66.11,111.13 63.69,113.54 63.69,127.23 64.09,127.62 70.92,127.62 71.43,127.12 72.95,127.12 72.96,127.1 72.96,123.54 73.09,123.42 73.09,119.99 74.47,118.61 75.74,118.61 76.01,118.34 76.01,114.78 76.65,114.15 76.65,111.73 78.68,109.7 78.68,108.72 78.04,108.08 78.04,105.13 78.93,104.24 78.93,102.62 78.55,102.24 78.55,99.92 79.3,99.18 85.41,99.18 85.41,97.29 85.16,97.03 85.16,93.33 83.36,93.33 82.98,92.95
1V_VCCGT on L3: 71.2,121.26 75.97,116.49 75.97,114.78 76.63,114.12 76.63,111.71 77.98,110.36 77.98,101.27 78.24,101.02 78.24,100.97 82.17,97.03 82.17,93.42 82.02,93.27 64.87,93.27 64.39,93.75 64.39,105.08 65.66,106.35 65.66,111.69 63.76,113.59 63.76,127.18 64.49,127.92 70.62,127.92 71.2,127.33
