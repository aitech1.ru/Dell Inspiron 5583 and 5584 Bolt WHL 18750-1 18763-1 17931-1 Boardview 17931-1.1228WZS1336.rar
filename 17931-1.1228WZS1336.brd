# Allegro board 17931-1.1228WZS1336.brd (continued)
## Nets (continued)
1D2V_S3: C804.1 C1130.1 C1131.1 C1132.1 C1136.1 C1137.1 C1138.1 C1139.1 C1140.1 C1141.1 C1142.1 C1202.1 C1203.1 C1204.1 C1205.1 C1206.1 C1208.1 C1209.1 C1210.1 C1214.1 C1215.1 C1216.1 C1217.1 C1218.1 C1219.1 C1220.1 C1221.1 C1303.1 C1304.1 C1305.1 C1306.1 C1307.1 C1308.1 C1309.1 C1310.1 C1315.1 C1316.1 C1317.1 C1318.1 C1319.1 C1320.1 C1321.1 C1322.1 C4008.1 C4043.1 CPU1.AD36 CPU1.AH32 CPU1.AH36 CPU1.AM36 CPU1.AN32 CPU1.AW32 CPU1.AY36 CPU1.BE32 CPU1.BH36 CPU1.R32 CPU1.Y36 DM1.12 DM1.33 DM1.54 DM1.75 DM1.96 DM1.111 DM1.112 DM1.117 DM1.118 DM1.123 DM1.124 DM1.129 DM1.130 DM1.135 DM1.136 DM1.141 DM1.142 DM1.147 DM1.148 DM1.153 DM1.154 DM1.159 DM1.160 DM1.163 DM1.178 DM1.199 DM1.220 DM1.241 DM2.12 DM2.33 DM2.54 DM2.75 DM2.96 DM2.111 DM2.112 DM2.117 DM2.118 DM2.123 DM2.124 DM2.129 DM2.130 DM2.135 DM2.136 DM2.141 DM2.142 DM2.147 DM2.148 DM2.153 DM2.154 DM2.159 DM2.160 DM2.163 DM2.178 DM2.199 DM2.220 DM2.241 EC1202.1 EC1203.1 EC1303.1 EC8901.1 EC8902.1 EC8903.1 EC8904.1 EC8905.1 EC8906.1 EC8907.1 EC8908.1 EC8909.1 EC8910.1 EC8911.1 EC8912.1 EC8913.1 EC8914.1 EC8915.1 FC1102.1 FC1103.1 FC8994.1 FC8995.1 FC8996.1 FC8997.1 PG5103.2 PG5105.2 PG5106.2 PG5107.2 PG5108.2 PG5109.2 PG5110.1 PG5116.1 R505.1 R1215.1 R1312.1 RN1201.1(A) RN1301.1(A) U4003.1 U4003.2 U4003.9
1D2V_VCCSFR_OC: C803.1 C4010.1 CPU1.BL27 CPU1.BM26 U4003.6 U4003.7 U4003.8
1D05V_PWR: PC5201.1 PC5203.1 PC5205.1 PC5206.1 PC5208.1 PC5217.1 PG5201.1 PG5202.1 PG5203.1 PG5204.1 PG5205.1 PG5206.1 PG5207.1 PG5208.1 PG5209.1 PG5211.1 PG5223.2 PL5201.2
1D05V_S5_PWRGD: PU5201.1 R4029.1
1D8V_1V_VGA_S0: C7614.1 C7620.1 C7621.1 C7622.1 C7627.1 C7628.1 C7629.1 C7630.1 C7631.1 GPU1.AA10 GPU1.AA12 GPU1.AA13 GPU1.AA16 GPU1.AA18 GPU1.AA19 GPU1.AA20 GPU1.AA21 GPU1.AB22 GPU1.AC23 GPU1.AD24 GPU1.AE25 GPU1.AF26 GPU1.AF27 L7801.2 L7901.1 L7902.1 R8605.1 R8606.1
1D8V_AON_EN: Q8701.2 U8601.5 U8802.4
1D8V_AON_S0: C8004.1 C8035.1 C8036.1 C8049.1 C8625.1 C8626.1 C8805.1 C8806.1 C8808.1 GPU1.G10 GPU1.G12 PR8563.1 Q7906.G R7603.2 R7905.1 R7909.1 R7912.2 R7914.1 R7917.1 R7919.1 R7922.1 R7931.1 R7933.1 R7947.2 R7949.2 R7976.1 R7977.1 R7978.1 R8608.2 R8704.1 RN7901.3(B) RN7901.4(B) RN7910.3(B) RN7910.4(B) U7601.5 U7602.5 U8601.8 U8601.9 U8801.5 U8803.5 U8804.5
1D8V_AON_S0_DISCHG: Q8701.3 R8704.2
1D8V_AVDD2: C2710.1 HDA27.33 R2725.2
1D8V_FBA_PLL_AVDD: C7805.1 C7808.1 C7809.1 C7818.1 GPU1.F16 GPU1.H22 GPU1.P22 L7801.1
1D8V_GPU_AON_S0: C8601.1 C8627.1 R8601.2 R8602.2 U8601.1 U8601.2 U8601.6 U8601.7
1D8V_MAIN_EN: D8801.K D8803.A R7933.2 R7936.2 R7963.2 R8801.1 R8803.1 R8811.2
1D8V_MAIN_EN_D: D8803.K R8809.2
1D8V_MAIN_EN_R: C8809.1 Q8704.2 R8811.1 U8601.3
1D8V_MAIN_ENABLE: GPU1.F9 R7936.1
1D8V_S0: C4015.1 R2709.1 R2725.1 R6403.1 U4004.8 U4004.9
1D8V_S0_CT1: C4011.1 U4004.10
1D8V_S5: PG5303.2 PG5304.2 PG5305.2 R1104.2 R1515.1 R2462.2 R2491.2 R2497.2 R8602.1 U4004.6 U4004.7
1D8V_VCCPRIM: C1122.1 C2210.1 C2211.1 CPU1.CC15 CPU1.CC18 CPU1.CC19 CPU1.CD15 CPU1.CD16 CPU1.CD18 CPU1.CD19 CPU1.CP17 CPU1.CP23 R1104.1 R1512.1 R1738.1 R1821.1 R2111.1 R2113.1 R2115.1 R2117.1 RN2001.1(A) RN2001.2(A)
1D8V_VGA_DISC: Q8704.5 Q8704.6 R8708.1
1D8V_VGA_PLL: C7905.1 C7906.1 GPU1.L6 L7901.2 R8003.1
1D8V_VGA_S0: C8003.1 C8028.1 C8029.1 C8034.1 C8050.1 C8603.1 GPU1.G8 GPU1.G9 Q7601.G Q7901.2 Q7901.5 R7946.2 R8605.2 R8607.2 R8707.1 R8810.1 U8601.13 U8601.14
1D8V_VGA_S0_DISCHG: Q8704.3 R8707.2
1D24V_VCCDPHY: CPU1.BY23 CPU1.BY24 CPU1.CA23 CPU1.CA24
1D24V_VCCDPHY_EC: C2218.1 CPU1.CP25
1D35V_PGOOD: PR8630.1 U7302.2 U8802.2
1D35V_PWR: PC8611.1 PC8613.1 PC8614.1 PC8620.1 PC8621.1 PG8609.1 PG8610.1 PG8611.1 PG8612.1 PG8613.1 PG8618.1 PG8619.1 PG8620.1 PG8621.1 PL8603.2
1D35V_VGA_EN#: Q8702.5 Q8702.6 R8705.1
1D35V_VGA_S0: C7801.1 C7802.1 C7807.1 C7810.1 C7811.1 C7812.1 C7813.1 C7814.1 C7817.1 C7819.1 C7820.1 C7821.1 C7822.1 C7823.1 C7824.1 C7825.1 C7826.1 C7827.1 C7828.1 C7829.1 C8104.1 C8105.1 C8106.1 C8107.1 C8108.1 C8109.1 C8110.1 C8111.1 C8112.1 C8113.1 C8114.1 C8115.1 C8116.1 C8117.1 C8118.1 C8119.1 C8120.1 C8121.1 C8122.1 C8123.1 C8124.1 C8125.1 C8204.1 C8205.1 C8206.1 C8207.1 C8209.1 C8210.1 C8211.1 C8212.1 C8213.1 C8214.1 C8215.1 C8216.1 C8217.1 C8218.1 C8219.1 C8220.1 C8221.1 C8222.1 C8223.1 C8224.1 C8225.1 C8226.1 GPU1.B26 GPU1.C25 GPU1.E23 GPU1.E26 GPU1.F14 GPU1.F21 GPU1.G13 GPU1.G14 GPU1.G15 GPU1.G16 GPU1.G18 GPU1.G19 GPU1.G20 GPU1.G21 GPU1.H24 GPU1.H26 GPU1.J21 GPU1.K21 GPU1.L22 GPU1.L24 GPU1.L26 GPU1.M21 GPU1.N21 GPU1.R21 GPU1.T21 GPU1.V21 GPU1.W21 PG8609.2 PG8610.2 PG8611.2 PG8612.2 PG8618.2 PG8619.2 PG8620.2 PG8621.2 R7803.2 R7804.2 R7805.2 R7816.2 R7824.2 R8106.1 R8112.2 R8203.1 R8210.2 R8709.1 VRAM1.B1 VRAM1.B3 VRAM1.B12 VRAM1.B14 VRAM1.C5 VRAM1.C10 VRAM1.D1 VRAM1.D3 VRAM1.D11 VRAM1.D12 VRAM1.D14 VRAM1.E5 VRAM1.E10 VRAM1.F1 VRAM1.F3 VRAM1.F12 VRAM1.F14 VRAM1.G1 VRAM1.G2 VRAM1.G4 VRAM1.G11 VRAM1.G13 VRAM1.G14 VRAM1.H3 VRAM1.H12 VRAM1.K3 VRAM1.K12 VRAM1.L1 VRAM1.L2 VRAM1.L4 VRAM1.L11 VRAM1.L13 VRAM1.L14 VRAM1.M1 VRAM1.M3 VRAM1.M12 VRAM1.M14 VRAM1.N5 VRAM1.N10 VRAM1.P1 VRAM1.P3 VRAM1.P11 VRAM1.P12 VRAM1.P14 VRAM1.R5 VRAM1.R10 VRAM1.T1 VRAM1.T3 VRAM1.T12 VRAM1.T14 VRAM2.B1 VRAM2.B3 VRAM2.B12 VRAM2.B14 VRAM2.C5 VRAM2.C10 VRAM2.D1 VRAM2.D3 VRAM2.D11 VRAM2.D12 VRAM2.D14 VRAM2.E5 VRAM2.E10 VRAM2.F1 VRAM2.F3 VRAM2.F12 VRAM2.F14 VRAM2.G1 VRAM2.G2 VRAM2.G4 VRAM2.G11 VRAM2.G13 VRAM2.G14 VRAM2.H3 VRAM2.H12 VRAM2.K3 VRAM2.K12 VRAM2.L1 VRAM2.L2 VRAM2.L4 VRAM2.L11 VRAM2.L13 VRAM2.L14 VRAM2.M1 VRAM2.M3 VRAM2.M12 VRAM2.M14 VRAM2.N5 VRAM2.N10 VRAM2.P1 VRAM2.P3 VRAM2.P11 VRAM2.P12 VRAM2.P14 VRAM2.R5 VRAM2.R10 VRAM2.T1 VRAM2.T3 VRAM2.T12 VRAM2.T14 VRAM3.B1 VRAM3.B3 VRAM3.B12 VRAM3.B14 VRAM3.C5 VRAM3.C10 VRAM3.D1 VRAM3.D3 VRAM3.D11 VRAM3.D12 VRAM3.D14 VRAM3.E5 VRAM3.E10 VRAM3.F1 VRAM3.F3 VRAM3.F12 VRAM3.F14 VRAM3.G1 VRAM3.G2 VRAM3.G4 VRAM3.G11 VRAM3.G13 VRAM3.G14 VRAM3.H3 VRAM3.H12 VRAM3.K3 VRAM3.K12 VRAM3.L1 VRAM3.L2 VRAM3.L4 VRAM3.L11 VRAM3.L13 VRAM3.L14 VRAM3.M1 VRAM3.M3 VRAM3.M12 VRAM3.M14 VRAM3.N5 VRAM3.N10 VRAM3.P1 VRAM3.P3 VRAM3.P11 VRAM3.P12 VRAM3.P14 VRAM3.R5 VRAM3.R10 VRAM3.T1 VRAM3.T3 VRAM3.T12 VRAM3.T14 VRAM4.B1 VRAM4.B3 VRAM4.B12 VRAM4.B14 VRAM4.C5 VRAM4.C10 VRAM4.D1 VRAM4.D3 VRAM4.D11 VRAM4.D12 VRAM4.D14 VRAM4.E5 VRAM4.E10 VRAM4.F1 VRAM4.F3 VRAM4.F12 VRAM4.F14 VRAM4.G1 VRAM4.G2 VRAM4.G4 VRAM4.G11 VRAM4.G13 VRAM4.G14 VRAM4.H3 VRAM4.H12 VRAM4.K3 VRAM4.K12 VRAM4.L1 VRAM4.L2 VRAM4.L4 VRAM4.L11 VRAM4.L13 VRAM4.L14 VRAM4.M1 VRAM4.M3 VRAM4.M12 VRAM4.M14 VRAM4.N5 VRAM4.N10 VRAM4.P1 VRAM4.P3 VRAM4.P11 VRAM4.P12 VRAM4.P14 VRAM4.R5 VRAM4.R10 VRAM4.T1 VRAM4.T3 VRAM4.T12 VRAM4.T14
1D35V_VGA_S0_DISCHG: Q8702.3 R8709.2
2D5V_S3: C1207.1 C1231.1 C1311.1 C1313.1 DM1.257 DM1.259 DM2.257 DM2.259 PR5121.1 PR5122.1
3D3V_AON_1D8V_VGA_S0: C7616.1 GPU1.AA8 GPU1.AA9 R7616.2 R8607.1 R8608.1
3D3V_AUX_S5: AFTP6402.1 C6401.2 PG4532.2 PR4505.1 PWR1.1 R1726.2 R1737.1 R2463.1 R2505.1 R7952.2
3D3V_CAMERA: F5504.1 R5501.2 U5503.13 U5503.14
3D3V_CAMERA_CT1: C5539.1 U5503.12
3D3V_CAMERA_S0: AFTP5511.1 C5503.1 F5504.2 FC8919.1 LCD1.23
3D3V_GSEN2: C7003.1 C7004.1 R7004.2 R7006.2 U7001.9 U7001.10
3D3V_LAN_CT2: C4017.1 U4001.10
3D3V_LAN_S5: C3103.1 C3110.1 C3117.1 C3121.1 C3124.1 C4014.1 LED2.A R3103.2 R4047.2 U3101.11 U3101.23 U3101.32
3D3V_LAN_S5_R: R4047.1 U4001.8 U4001.9
3D3V_LCDVDD_S0: AFTP5523.1 C5530.1 C5536.1 C5538.1 C5541.1 C5599.1 D5505.A FC8964.1 LCD1.35 LCD1.36 LCD1.37 U5501.1
3D3V_MUX: C7115.2 C7116.2 C7117.2 C7118.2 C7119.1 L7101.2 R7101.1 R7140.1 R7142.1 R7145.1 R7147.1 R7152.1 R7171.1 R7174.1 R7175.1 R7189.1 R7190.1 U7101.6 U7101.20 U7101.28
3D3V_MUX2: C7120.1 R7126.2 U7102.13
3D3V_MUX_VCC: C7165.2 R7175.2 U7101.1
3D3V_RTC: C2503.1 D2501.3 Q2507.S R2472.2 R2708.1
3D3V_RTC_AUX_S5: Q2507.D R1730.1 R2204.1 R2476.2 R2506.2 RN1801.1(A) RN1801.2(A)
3D3V_RTC_SYS: D2501.1 R2505.2 R2517.1
3D3V_S0: AFTP6611.1 C1228.1 C1328.1 C1329.1 C2432.1 C2601.1 C2602.1 C4004.1 C5809.2 C5810.2 C5811.1 C5812.1 C5813.1 C8807.1 C9104.1 DBG1.10 DM1.255 DM2.255 EC8950.1 EC8951.1 EC8952.1 EC8953.1 EC8959.1 EC8960.1 EC8975.1 EC8977.1 EC8978.1 EC8979.1 EC8980.1 EC8991.1 EC8992.1 EC8993.1 EC8994.1 EC8995.1 EC8996.1 EC8997.1 EC8998.1 EC8999.1 EC9001.1 FC8901.1 FC8907.1 FC8970.1 FC8984.1 FC8998.1 IOBD1.14 IOBD1.15 PG8605.1 PR4609.1 PR8530.1 PR8611.1 PR8634.2 Q1801.2 Q1801.5 Q2414.G Q2601.2 Q2601.5 Q5702.2 Q5702.5 Q5703.C Q5801.2 Q5801.5 Q6504.2 Q6504.5 R407.2 R507.1 R1204.2 R1208.2 R1211.2 R1216.1 R1302.2 R1306.2 R1310.2 R1606.1 R1617.1 R1820.1 R1822.1 R1823.1 R1824.1 R1825.1 R1826.1 R1827.1 R2008.1 R2010.1 R2043.1 R2044.1 R2045.1 R2046.1 R2048.1 R2049.1 R2053.1 R2059.1 R2064.1 R2065.1 R2066.1 R2430.2 R2467.2 R2489.2 R2603.1 R2604.1 R2617.1 R2618.1 R2715.1 R3109.1 R4005.1 R4010.1 R5501.1 R5517.1 R5518.1 R5550.2 R5556.2 R5557.1 R5564.2 R5805.1 R5807.1 R5809.1 R5811.1 R5813.1 R5815.1 R5817.1 R5820.1 R5821.1 R5822.1 R5834.1 R6124.2 R6302.1 R6348.1 R6349.1 R6411.1 R6415.1 R6502.1 R7004.1 R7010.1 R7948.2 R7953.1 R8701.2 R8703.2 R8705.2 R8708.2 R8710.2 R8806.1 R9150.1 R9211.2 RN401.1(A) RN401.2(A) RN401.3(A) RN401.4(A) RN1810.1(A) RN1810.2(A) RN2601.1(A) RN2601.2(A) U2402.5 U2601.1 U4001.13 U4001.14 U5503.1 U5503.2 U5802.5 U5802.21 U5802.30 U5802.51 U5802.57 U7302.5 U8802.5 U9103.8 VGABD1.3 VGABD1.4
3D3V_S5: C2416.1 C2421.1 C5505.1 C6102.1 C6502.1 C9106.1 C9108.1 D4302.2 D7202.A EC8940.1 EC8941.1 EC8942.1 EC8943.1 EC8944.1 EC8945.1 EC8946.1 FC8911.1 FC8966.1 FC8967.1 L7101.1 PC4509.1 PC4510.1 PC4511.1 PC4512.1 PC4513.1 PC4525.1 PC5124.1 PG4530.2 PG5301.1 PG5302.1 PL4501.2 PR4431.1 PR4432.2 PR4435.1 PR4450.2 PR4472.1 PR5101.1 PR5112.1 PR5306.1 PU5101.5 PU5101.9 Q2416.2 Q2416.5 Q6502.S Q9201.S R506.1 R1721.1 R1739.2 R1910.1 R2434.1 R2442.1 R2446.1 R2492.1 R2495.1 R2498.1 R2499.1 R2514.1 R2520.1 R2607.1 R4031.1 R4048.1 R4304.1 R4378.1 R5547.2 R6102.1 R6125.1 R6404.2 R6611.1 R7126.1 R7216.1 R7424.1 R7427.1 R8601.1 R9149.1 R9212.1 RN2405.3(B) RN2405.4(B) U2502.5 U4001.1 U4001.2 U4001.6 U4001.7 U4007.5 U4302.2 U5501.5 U6101.5 U9103.1 WWAN1.1 WWAN1.2 WWAN1.3 WWAN1.4 WWAN1.5
3D3V_S5_PCH: FC8999.1 R405.1 R406.1 R1103.1 R1502.1 R1504.1 R1506.1 R1508.1 R1510.1 R1513.1 R1522.1 R1551.1 R1554.1 R1837.1 R2041.1 R2047.1 R2055.1 R2060.1 R2061.1 R2062.1 R2068.1 R2119.1 R2515.1 R2516.2 R2519.1 R2521.1 R6609.1 R6877.2 R9148.1 RN1601.1(A) RN1601.2(A) RN1601.3(A) RN1601.4(A) RN1807.1(A) RN1807.2(A) RN1807.3(A) RN1807.4(A) RN1811.1(A) RN1811.2(A)
3D3V_S5_PCH_R: Q401.2 Q401.3 R406.2
3D3V_SPIVCC1: BIOS1.8 BIOS2.8 C2501.1 C2502.1 R2515.2
3D3V_SSD: C6304.1 C6305.1 C6306.1 C6307.1 C6308.1 C6317.1 C6318.1 FC8962.1 R6302.2 R6349.2 SSD1.2 SSD1.4 SSD1.12 SSD1.14 SSD1.16 SSD1.18 SSD1.70 SSD1.72 SSD1.74
3D3V_TP_CT2: C5540.1 U5503.10
3D3V_TPM: C9109.1 C9112.1 C9113.1 R9119.2 R9149.2 R9150.2 U9103.22
3D3V_VCCDSW: C2224.1 C2230.1 CPU1.BR24 CPU1.BT23 R1520.1 R1524.1 R1707.1 R2516.1 RN1704.1(A) RN1704.2(A) RN1704.3(A) RN1704.4(A) U2502.1
3D3V_VCCPRIM: C1113.1 C1123.1 C2202.1 C2203.1 C2204.1 C2205.1 C2206.1 C2207.1 C2225.1 C2226.1 C2227.1 C2228.1 CPU1.BP23 CPU1.BT20 CPU1.BV23 CPU1.BW23 CPU1.CB16 CPU1.CB22 CPU1.CB23 CPU1.CC22 CPU1.CC23 CPU1.CD22 CPU1.CD23 CPU1.CP29 R1103.2 R1701.1 R1731.1
3D3V_VCCPRTC: C2221.1 C2222.1 C2229.1 CPU1.BR23 R2204.2
3D3V_WLAN: AFTP6113.1 C6104.1 C6105.1 C6106.1 FC9005.1 FC9006.1 R6114.1 R6115.1 R6124.1 R6125.2 U6101.1 WLAN1.2 WLAN1.4 WLAN1.72 WLAN1.74
27MHZ_IN: C7907.2 GPU1.C11 R7903.1 X7901.1
27MHZ_OUT: GPU1.B10 R7903.2 R7904.2
27MHZ_OUT_R: C7908.2 R7904.1 X7901.3
+DC_IN: C4301.1 C4302.1 EL4301.2 EL4302.2 PU4301.1 PU4301.2 PU4301.3 Q4305.2 R4307.1 R4376.1
+DC_IN_C: AFTP4303.1 D4301.K DCIN1.6 DCIN1.7 DCIN1.8 EC4301.1 EC4302.1 EC4312.1 EC4313.1 EL4301.1 EL4302.1
+RTC_CELL_VBAT: C2428.1 R2451.2 R2472.1 R2476.1 R2496.2 U2401.122
+RTC_VCC: AFTP6615.1 D2501.2 IOBD1.13 Q2505.G R2504.1
+SDC_IN: C4444.1 C7401.1 EC8969.1 EC8971.1 EC8972.1 EC8973.1 EC8974.1 EC8976.1 PG4401.1 PR4401.1 PR4434.2 PU4302.1 PU4302.2 PU4302.3 Q4448.S Q7401.S R4464.1 R4468.1 R7406.1 R7407.2 R7432.1 U7418.1 U7418.2 U7418.3
+SDC_IN_SW: C4444.2 PU4302.4 R4464.2 R4465.2 R4466.1
+SDC_IN_SW_R1: Q4449.3 R4465.1
+V_VREF_PATH1: C1222.2 R1209.1
+V_VREF_PATH2: C1323.2 R1309.1
AC_DIS: Q4304.B R4312.1 R4481.2 U2401.69
AC_IN#_G: R4376.2 R4377.1 U4302.5
AC_PRESENT: CPU1.BU35 D1701.A EC1707.1 Q1702.3 RN1704.7(B)
ACOK#: PQ4415.2 PQ4415.3 PR4427.2
ACOK_IN_M: D1701.K D4305.K PQ4415.6
AD_IA: PC4432.1 PR4412.1 R2421.1
AD_OFF_L: Q4304.C Q4305.1
AD_OFF_R: C4301.2 PU4301.4 Q4305.3 R4307.2 R4308.1
ALERT#: R2603.2 U2601.6
ALWON: R4009.2 U2401.121
AMBER_LED_BAT: EC6402.1 Q6403.C R6407.1
AON_CT_2: C8605.1 U8601.10
AUD_AGND: C2702.1 C2703.2 C2706.2 C2707.2 C2710.2 C2711.2 C2715.2 C2902.2 EC2701.1 EC2702.1 EC2703.1 EC2704.1 EC2705.1 EC2905.2 EC2906.2 EC2907.2 EC2908.2 HDA27.19 HDA27.31 HPMIC1.MS R2702.2 R2704.1 R2705.1 R2914.2
AUD_HP1_JACK_L: HDA27.25 R2908.1 R2913.2 R2922.2
AUD_HP1_JACK_L1: EC2907.1 R2907.1 R2908.2
AUD_HP1_JACK_R: HDA27.26 R2910.1 R2912.2 R2921.2
AUD_HP1_JACK_R1: EC2908.1 R2909.1 R2910.2
AUD_HPJD_N: HDA27.12 R2710.2 R2711.2
AUD_PC_BEEP: C2735.2 HDA27.11
AUD_PC_BEEP_C: C2735.1 D2703.3 R2735.1
AUD_PORTA_L_HPMIC1: ED2910.1 HPMIC1.1 R2907.2
AUD_PORTA_R_HPMIC1: ED2910.2 HPMIC1.2 R2909.2
AUD_RING: EC2905.1 HDA27.13 R2906.1 RN2901.4(B)
AUD_SENSE: C2902.1 R2711.1 R2923.2
AUD_SLEEVE: EC2906.1 HDA27.14 R2911.1 RN2901.3(B)
AUD_SPK_L+: EC2904.1 HDA27.35 R2926.1
AUD_SPK_L+_C: AFTP2902.1 R2926.2 SPK1.3
AUD_SPK_L-: EC2903.1 HDA27.36 R2927.1
AUD_SPK_L-_C: AFTP2901.1 R2927.2 SPK1.4
AUD_SPK_R+: EC2902.1 HDA27.38 R2924.1
AUD_SPK_R+_C: AFTP2904.1 R2924.2 SPK1.1
AUD_SPK_R-: EC2901.1 HDA27.37 R2925.1
AUD_SPK_R-_C: AFTP2903.1 R2925.2 SPK1.2
AUD_VREF: C2702.2 HDA27.22
AUX_EN_WOWL: CPU1.BT30 R1718.2
AUX_EN_WOWL_R: Q6102.S R1718.1 R2409.2
AUX_ON: R2466.2 U2401.3
BAT1_LED#: Q2416.4 R2452.1 RN2405.1(A) U2401.106
BAT2_LED#: Q2416.1 R2453.2 RN2405.2(A) U2401.1
BAT_AMBER: LED1.1 R6407.2
BAT_WHITE: LED1.2 R6406.2
BATT_WHITE_LED#: Q2416.6 Q6401.D Q6406.4 R2453.1 R6409.2
BATT_WHITE_LED#_Q: Q6404.B Q6406.3 R6409.1
BEEP: R2739.1 U2401.45
BKLT_CTRL: D5503.3 RN5502.2(A) RN5503.3(A)
BKLT_IN_EC: R2435.1 U2401.67
BLON_OUT_C: LCD1.30 RN5503.5(B)
BLUETOOTH_EN: AFTP6112.1 CPU1.CP14 R6108.2
BLUETOOTH_EN_R: R6108.1 R6115.2 WLAN1.54
BMON22: PR4493.2 R2483.1
BOARD_ID: C2408.1 R2443.2 R2444.1 U2401.111
BOARD_ID1: CPU1.CG12 R2009.1 R2010.2
BOT_MUX_N: ED7313.2 EL7106.2 R7334.2
BOT_MUX_N_L: EL7106.1 U7102.9
BOT_MUX_N_R: JUSB1.B7 R7333.1 R7334.1
BOT_MUX_P: ED7314.2 EL7106.3 R7335.2
BOT_MUX_P_L: EL7106.4 U7102.8
BOT_MUX_P_R: JUSB1.B6 R7332.1 R7335.1
BPM_CPU_N0: CPU1.U1 TP307.1
BPM_CPU_N1: CPU1.U2 TP308.1
BPM_CPU_N2: CPU1.U3 TP302.1
BPM_CPU_N3: CPU1.U4 TP303.1
BREATH_LED#: R2467.1 U2401.70 U2402.1
BT+: AFTP4312.1 AFTP4313.1 AFTP4402.1 BATT1.1 BATT1.2 BATT1.3 D4304.K EC4307.1 EC4308.1 PC4427.1 PC4446.1 PC4447.1 PC4448.1 PG4422.2 PR4452.1 PR4478.2 PU4412.5 PU4412.6 PU4412.7 PU4412.8
BT_PCMFRM_RSTN: R1913.1 R6122.1 WLAN1.10
BT_PCMOUT_CLKREQ0: R1912.1 R6121.1 WLAN1.14
BT_USB20_CON_N: AFTP6111.1 EL6101.1 R6105.1 WLAN1.5
BT_USB20_CON_P: AFTP6114.1 EL6101.4 R6104.1 WLAN1.3
BT_USB20_N: CPU1.CC3 EL6101.2 R6105.2
BT_USB20_P: CPU1.CC4 EL6101.3 R6104.2
C10_GATE: R4010.2 R4034.2 R4040.2 R4048.2 U4007.2
CAD_SNK_MUX: R7189.2 U7101.29
CAM_EN: CPU1.CE9 R5556.1 U5503.3
CAP_LED: AFTP6541.1 KB1.4 R6513.2
CAP_LED#: Q2414.S R2489.1 U2401.93
CAP_LED#_R: Q2414.D Q6505.B
CAP_LED_Q: C6506.1 Q6505.C R6513.1
CARD1_USB20_CON_N: ED6601.1 EL6601.3 IOBD1.5 R6604.2
CARD1_USB20_CON_P: ED6601.6 EL6601.2 IOBD1.6 R6605.2
CARD1_USB20_N: CPU1.CG8 EL6601.4 R6604.1
CARD1_USB20_P: CPU1.CG9 EL6601.1 R6605.1
CATERR#_CPU: CPU1.AA4 TP301.1
CBN: C2708.1 HDA27.28
CBP: C2708.2 HDA27.30
CCD_USB20_CON_N: ED5502.1 EL5501.2 LCD1.20
CCD_USB20_CON_P: ED5502.6 EL5501.3 LCD1.19
CCD_USB20_N: CPU1.CC1 EL5501.1
CCD_USB20_P: CPU1.CC2 EL5501.4
CCG4_FLIP#: R7127.1 R7128.1 U7201.24
CCG4_I2C_INT#: R7215.2 U2401.32 U7201.8
CCG4_I2C_SCL: Q2417.6 RN7201.3(B) U7201.10
CCG4_I2C_SDA: Q2417.3 RN7201.4(B) U7201.9
CCG4_ID_1: R7212.2 R7214.1 U7201.2
CEXT: C5863.1 U5802.17
CFG0_DP_MUX: R5815.2 U5802.59
CFG3: CPU1.R3 R1517.1
CFG4: CPU1.J4 R1518.1
CFG_RCOMP: CPU1.AB5 R601.1
CHG_AMBER_LED#: Q2416.3 Q6406.1 R2452.2 R6408.1
CHG_AMBER_LED#_Q: Q6403.B Q6406.6 Q6407.2 R6405.2 R6408.2
CHGR_PSYS_IMVP: PR4442.2 PR4671.2
CLK_ITE8010: R2460.1 WWAN1.14
CLK_PCIE_LAN_REQ#: CPU1.CF30 R1826.2 U3101.12
CLK_PCIE_NVME_REQ#: CPU1.CE30 R1822.2 SSD1.52
CLK_PCIE_PEG_REQ#: CPU1.CF32 Q7601.D R1824.2
CLK_PCIE_SD_REQ#: CPU1.CE31 R1823.2
CLK_PCIE_WLAN_REQ#: AFTP6109.1 CPU1.CE32 R1827.2 WLAN1.53
CLK_TP_SIO: EC6503.1 RN6501.3(B) RN6502.1(A) U2401.78
CLKIN_XTAL_LCP: C1809.1 CPU1.CM3 R1804.1 R1817.1
CMP_VIN0: R2470.2 U2401.20
CMP_VIN0_R: C2612.1 C2613.1 R2470.1 R2608.2 R2610.1
CMP_VOUT0: R2602.2 R2607.2 R2615.2 U2401.85
CNV_BRI_DT: CPU1.CJ20 R2058.2
CNV_BRI_DT_R: R2058.1 WLAN1.36
CNV_BRI_RSP: CPU1.CK20 R6123.1 RN2001.3(B)
CNV_BRI_RSP_R: R6123.2 WLAN1.22
CNV_MFUART2_RXD: CPU1.CJ17 TP2102.1
CNV_MFUART2_TXD: CPU1.CH17 TP2103.1
CNV_PA_BLANKING: CPU1.CP20 TP2101.1
CNV_RGI_DT: CPU1.CG19 R2057.2
CNV_RGI_DT_R: R1515.2 R1516.1 R2057.1 WLAN1.32
CNV_RGI_RSP: CPU1.CH19 R6120.1 RN2001.4(B)
CNV_RGI_RSP_R: R6120.2 WLAN1.34
CNV_WR_CLK_DN: CPU1.CN31 WLAN1.21
CNV_WR_CLK_DP: CPU1.CP31 WLAN1.23
CNV_WR_DN0: CPU1.CR30 WLAN1.15
CNV_WR_DN1: CPU1.CM30 WLAN1.9
CNV_WR_DP0: CPU1.CP30 WLAN1.17
CNV_WR_DP1: CPU1.CN30 WLAN1.11
CNV_WT_CLK_DN: CPU1.CP34 WLAN1.71
CNV_WT_CLK_DP: CPU1.CN34 WLAN1.73
CNV_WT_DN0: CPU1.CN32 WLAN1.65
CNV_WT_DN1: CPU1.CP33 WLAN1.59
CNV_WT_DP0: CPU1.CM32 WLAN1.67
CNV_WT_DP1: CPU1.CN33 WLAN1.61
CNV_WT_RCOMP: CPU1.CP32 CPU1.CR32 R2101.1
CNVI_EN#: CPU1.CR26 R6110.2
CNVI_EN#_R: Q6102.G R6101.1 R6110.1
CPU_DP1_CTRL_CLK: CPU1.CC8 FC8986.1 Q5702.4 RN401.6(B)
CPU_DP1_CTRL_DATA: CPU1.CC9 Q5702.1 RN401.5(B)
CPU_DP1_HPD: CPU1.CN6 Q5703.E R5782.1
CPU_DP2_CTRL_CLK: CPU1.CH4 RN401.7(B)
CPU_DP2_CTRL_DATA: CPU1.CH3 RN401.8(B)
CPU_DP2_HPD: CPU1.CM6 Q401.6 R403.2 R404.1 R405.2
CPU_DP_HPD_MUX: R7206.1 U7201.11
CPU_DP_HPD_R: R7118.2 R7176.2 R7202.2 R7206.2 R7219.1 U5802.48
CPU_POPIRCOMP: CPU1.BP27 R304.1
CPU_SMB_SCL_THM: Q2601.4 R2617.2 U2601.8
CPU_SMB_SDA_THM: Q2601.1 R2618.2 U2601.7
CPVDD: C2704.1 C2705.1 HDA27.29 R2709.2
CPVEE: C2709.1 HDA27.27
CRT_AUX_CPU_N: R5822.2 R5825.1 R5831.1 VGABD1.14
CRT_AUX_CPU_N_R: R5831.2 R5845.1
CRT_AUX_CPU_P: R5823.2 R5824.1 R5830.1 VGABD1.13
CRT_AUX_CPU_P_R: R5830.2 R5844.1
CRT_DDI_TX_N0: R5826.1 R5841.1 VGABD1.7
CRT_DDI_TX_N1: R5829.1 R5843.1 VGABD1.10
CRT_DDI_TX_P0: R5827.1 R5840.1 VGABD1.8
CRT_DDI_TX_P1: R5828.1 R5842.1 VGABD1.11
CRT_DP_HPD: R5605.2 U5802.38
CRT_DP_HPD_R: AFTP5602.1 R5605.1 VGABD1.18
CTL1: R3601.2 U3601.6
CTL2: R3606.2 U3601.7
CTL3: R3602.2 U3601.8
DAT_ITE8010: R2455.1 WWAN1.13
DAT_TP_SIO: EC6501.1 RN6501.4(B) RN6502.2(A) U2401.79
DBC_EN_R: AFTP5522.1 LCD1.34 R5504.2
DBC_PANEL_EN: CPU1.CA31 R2043.2 R5504.1
DC_IN_OFF: Q4449.6 R4467.2 R4470.2
DCBATOUT: AFTP4403.1 AFTP4407.1 C8501.1 C8502.1 EC4534.2 EC8923.1 EC8924.1 EC8925.1 EC8927.1 EC8929.1 EC8930.1 EC8932.1 EC8955.1 EC8957.1 EC8962.1 EC8963.2 EC8964.2 F5503.2 FC8921.1 FC8922.1 FC8923.1 FC8924.1 FC8929.1 FC8930.1 FC8931.1 FC8932.1 FC8933.1 FC8934.1 FC8935.1 FC8936.1 FC8937.1 FC8938.1 FC8939.1 FC8940.1 FC8941.1 FC8942.1 FC8944.1 FC8945.1 FC8946.1 FC8947.1 FC8948.1 FC8951.1 FC8952.1 FC8953.1 FC8954.1 FC8955.1 FC8956.1 FC8957.1 FC8958.1 FC8959.1 FC8960.1 FC8965.1 PC4406.1 PC4407.1 PC4408.1 PC4409.1 PC4410.1 PC4411.1 PC4412.1 PC4413.1 PC4414.1 PC4418.1 PC4434.1 PC4437.1 PC4443.1 PC4501.1 PC4502.1 PC4503.1 PC4504.1 PC4505.1 PC4519.1 PC4522.1 PC4523.1 PC8501.1 PC8502.1 PC8503.1 PC8504.1 PC8505.1 PC8506.1 PC8561.1 PC8562.1 PC8576.1 PC8578.1 PD4401.2 PG4415.2 PG4419.2 PG5002.2 PG5003.2 PG5101.1 PG5102.1 PG5104.1 PG5210.1 PG5212.1 PG5214.1 PG8614.1 PG8615.1 PG8616.1 PG8617.1 PL4702.1 PL4703.1 PL4803.1 PL4804.1 PR4477.1 PR4509.1 PR4511.1 PR4612.1 PR8552.1 PU4405.5 PU4405.6 PU4405.7 PU4405.8 PU4413.1 PU4413.2 PU4413.3 PU4501.2 PU4501.3 PU4501.4 PU4501.5 PU4502.2 PU4502.3 PU4502.4 PU4502.5 PU8510.2 PU8510.3 PU8510.4 PU8510.10 PU8512.2 PU8512.3 PU8512.4 PU8512.10 PU8515.2 PU8515.3 PU8515.4 PU8515.10 PU8516.2 PU8516.3 PU8516.4 PU8516.10 R5551.2
DCBATOUT_LCD: AFTP5525.1 C5512.1 C5513.1 C5514.1 C5528.1 D5504.A F5503.1 FC8963.1 LCD1.39 LCD1.40
DCBATOUT_LCD_PG: Q5505.1 R5546.2
DCBATOUT_LCD_PWRGD: C5531.1 D5504.K R5554.1 R5555.1
DDR4_DRAMRST#: C501.1 DM1.108 DM2.108 ED1217.1 ED1217.2 ED1302.1 ED1302.2 R504.2
DGPU_HOLD_RST#: CPU1.CR22 EC2002.1 R2054.2 U7601.1
DGPU_PWR_EN: CPU1.CM24 R2055.2 R8808.2
DGPU_PWR_EN_1: R8808.1 U8801.1 U8802.1
DGPU_PWR_EN_2: C8804.1 D8801.A R8803.2 U8801.2
DGPU_PWROK: CPU1.CJ25 R2471.1 U7302.4
DGPU_TXN_CPU_RXN0: C7602.2 GPU1.AB9
DGPU_TXN_CPU_RXN1: C7604.2 GPU1.AC10
DGPU_TXN_CPU_RXN2: C7606.2 GPU1.AC11
DGPU_TXN_CPU_RXN3: C7608.2 GPU1.AB12
DGPU_TXP_CPU_RXP0: C7601.2 GPU1.AC9
DGPU_TXP_CPU_RXP1: C7603.2 GPU1.AB10
DGPU_TXP_CPU_RXP2: C7605.2 GPU1.AD11
DGPU_TXP_CPU_RXP3: C7607.2 GPU1.AC12
DMIC_CLK_EDP: AFTP5510.1 EC5504.1 LCD1.22 RN5504.2(A) RN5505.1(A)
DMIC_DATA_EDP: AFTP5509.1 EC5503.1 LCD1.21 RN5504.1(A) RN5505.2(A)
DMIC_PCH_CLK: CPU1.CP24 RN5505.4(B)
DMIC_PCH_DATA: CPU1.CN24 RN5505.3(B)
DMIC_SCL_CODEC: EC2707.1 R2738.1 RN5504.3(B)
DMIC_SCL_CODEC_R: HDA27.3 R2738.2
DMIC_SDA_CODEC: EC2708.1 HDA27.2 RN5504.4(B)
DOCK_USB_EN_A: U7102.16 U7201.18
DOCK_USB_EN_B: U7102.10 U7201.13
DP2_AUX_C_N: R7101.2 R7104.2 U7101.25
DP2_AUX_C_P: R7102.2 R7103.2 U7101.24
DP2_AUX_CPU_N: C5854.1 CPU1.AD4 R5845.2
DP2_AUX_CPU_P: C5862.1 CPU1.AD3 R5844.2
DP2_DDI_TX_C_N2: C5806.2 R5856.1
DP2_DDI_TX_C_N2_R: R5856.2 U5802.13
DP2_DDI_TX_C_N3: C5808.2 R5858.1
DP2_DDI_TX_C_N3_R: R5858.2 U5802.16
DP2_DDI_TX_C_P2: C5805.2 R5855.1
DP2_DDI_TX_C_P2_R: R5855.2 U5802.12
DP2_DDI_TX_C_P3: C5807.2 R5857.1
DP2_DDI_TX_C_P3_R: R5857.2 U5802.15
DP2_DDI_TX_N0: C5804.1 CPU1.AC4 R5832.2
DP2_DDI_TX_N1: C5802.1 CPU1.AC1 R5839.2
DP2_DDI_TX_N2: C5806.1 CPU1.AE4
DP2_DDI_TX_N3: C5808.1 CPU1.AE1
DP2_DDI_TX_P0: C5803.1 CPU1.AC3 R5833.2
DP2_DDI_TX_P1: C5801.1 CPU1.AC2 R5838.2
DP2_DDI_TX_P2: C5805.1 CPU1.AE3
DP2_DDI_TX_P3: C5807.1 CPU1.AE2
DP2_DDI_TX_R_N0: C5804.2 R5859.1
DP2_DDI_TX_R_N0_R: R5859.2 U5802.7
DP2_DDI_TX_R_N1: C5802.2 R5861.1
DP2_DDI_TX_R_N1_R: R5861.2 U5802.10
DP2_DDI_TX_R_P0: C5803.2 R5854.1
DP2_DDI_TX_R_P0_R: R5854.2 U5802.6
DP2_DDI_TX_R_P1: C5801.2 R5860.1
DP2_DDI_TX_R_P1_R: R5860.2 U5802.9
DP2_DDI_TX_RE_C_N0: R7178.2 U7101.10
DP2_DDI_TX_RE_C_N1: R7180.2 U7101.13
DP2_DDI_TX_RE_C_N2: R7182.2 U7101.16
DP2_DDI_TX_RE_C_N3: R7184.2 U7101.19
DP2_DDI_TX_RE_C_P0: R7177.2 U7101.9
DP2_DDI_TX_RE_C_P1: R7179.2 U7101.12
DP2_DDI_TX_RE_C_P2: R7181.2 U7101.15
DP2_DDI_TX_RE_C_P3: R7183.2 U7101.18
DP2_DEMUX_OUT2_D0N: R5841.2 U5802.39
DP2_DEMUX_OUT2_D0N_R: R5826.2 R5832.1
DP2_DEMUX_OUT2_D0P: R5840.2 U5802.40
DP2_DEMUX_OUT2_D0P_R: R5827.2 R5833.1
DP2_DEMUX_OUT2_D1N: R5843.2 U5802.36
DP2_DEMUX_OUT2_D1N_R: R5829.2 R5839.1
DP2_DEMUX_OUT2_D1P: R5842.2 U5802.37
DP2_DEMUX_OUT2_D1P_R: R5828.2 R5838.1
DP2_HPD_CPU: Q401.5 R404.2 U5802.3
DPEQ0_A1: R7171.2 R7172.1 U7101.14
DPEQ1: R7147.2 R7170.1 U7101.2
EC_D_INHIB: C6405.1 D6403.A Q6408.B R6404.1 R6414.1 U2401.96
EDP_AUX_CON_N: C5521.2 LCD1.3
EDP_AUX_CON_P: C5526.2 LCD1.2
EDP_AUX_CPU_N: C5521.1 CPU1.AH4
EDP_AUX_CPU_P: C5526.1 CPU1.AH3
EDP_FHD_DET#: CPU1.CL36 R2068.2 R5565.2
EDP_FHD_DET#_R: LCD1.10 R5565.1
EDP_HPD: CPU1.CM7 RN5502.4(A) RN5503.1(A)
EDP_HPD_CONN: AFTP5521.1 LCD1.33 RN5503.8(B)
EDP_RCOMP_CPU: CPU1.AM6 FC8985.1 R401.2
EDP_TX_CON_N0: C5525.2 LCD1.6
EDP_TX_CON_N1: C5523.2 LCD1.9
EDP_TX_CON_P0: C5524.2 LCD1.5
EDP_TX_CON_P1: C5522.2 LCD1.8
EDP_TX_CPU_N0: C5525.1 CPU1.AG4
EDP_TX_CPU_N1: C5523.1 CPU1.AG2
EDP_TX_CPU_P0: C5524.1 CPU1.AG3
EDP_TX_CPU_P1: C5522.1 CPU1.AG1
EDP_VDD_EN: CPU1.CG11 D5502.1
EMMC_RCOMP: CPU1.CK15 R2108.1
EQ0: R7142.2 R7143.1 U7101.38
EQ1: R7140.2 R7141.1 U7101.35
ESPI_ALERT#: CPU1.BV28 R1821.2
ESPI_CLK: DBG1.2 EC1801.1 R1805.2 U2401.57
ESPI_CS#: CPU1.CA28 DBG1.5 U2401.58
ESPI_IO0: DBG1.9 RN1806.8(B) U2401.59
ESPI_IO1: DBG1.8 RN1806.6(B) U2401.60
ESPI_IO2: DBG1.7 RN1806.7(B) U2401.61
ESPI_IO3: DBG1.6 RN1806.5(B) U2401.62
ESPI_RESET#: CPU1.CA27 DBG1.4 U2401.53
EXT_PWR_GATE#: CPU1.CC37 R1731.2
FALL_INT2: Q7001.2 Q7001.3 R7010.2
FAN1_PWM: EC2601.1 R2614.1 RN2601.3(B) U2401.47
FAN1_TACH: D2403.A R2430.1 U2401.40
FAN_PWM1_C: AFTP2602.1 FAN1.4 R2614.2
FAN_TACH1: D2403.K EC2602.1 R2613.1 RN2601.4(B)
FAN_TACH1_C: AFTP2601.1 FAN1.3 R2613.2
FB_CAL_PD_VDDQ: GPU1.D22 R7805.1
FB_CAL_PU_GND: GPU1.C24 R7807.1
FB_CAL_TERM_GND: GPU1.B25 R7806.1
FB_CLAM: GPU1.F3 R7818.1
FBA_CLK0_MIDPT: C8101.2 R8101.2 R8102.2
FBA_CLK0N: GPU1.D25 R8102.1 VRAM1.J11 VRAM2.J11
FBA_CLK0P: GPU1.D24 R8101.1 VRAM1.J12 VRAM2.J12
FBA_CLK1_MIDPT: C8201.2 R8206.2 R8208.2
FBA_CLK1N: GPU1.M22 R8206.1 VRAM3.J11 VRAM4.J11
FBA_CLK1P: GPU1.N22 R8208.1 VRAM3.J12 VRAM4.J12
FBA_CMD0: GPU1.C27 VRAM1.G12 VRAM2.L12
FBA_CMD1: GPU1.C26 VRAM1.H10 VRAM2.K10
FBA_CMD2: GPU1.E24 VRAM1.H11 VRAM2.K11
FBA_CMD3: GPU1.F24 VRAM1.K11 VRAM2.H11
FBA_CMD4: GPU1.D27 VRAM1.K10 VRAM2.H10
FBA_CMD5: GPU1.D26 VRAM1.L12 VRAM2.G12
FBA_CMD6: GPU1.F25 VRAM1.K4 VRAM2.H4
FBA_CMD7: GPU1.F26 VRAM1.K5 VRAM2.H5
FBA_CMD8: GPU1.F23 VRAM1.J4 VRAM2.J4
FBA_CMD9: GPU1.G22 VRAM1.J5 VRAM2.J5
FBA_CMD10: GPU1.G23 VRAM1.H4 VRAM2.K4
FBA_CMD11: GPU1.G24 VRAM1.H5 VRAM2.K5
FBA_CMD12: GPU1.F27 VRAM1.G3 VRAM2.L3
FBA_CMD13: GPU1.G25 R7820.2 VRAM1.J2 VRAM2.J2
FBA_CMD14: GPU1.G27 R7816.1 VRAM1.J3 VRAM2.J3
FBA_CMD15: GPU1.G26 VRAM1.L3 VRAM2.G3
FBA_CMD16: GPU1.M24 VRAM3.G12 VRAM4.L12
FBA_CMD17: GPU1.M23 VRAM3.H10 VRAM4.K10
FBA_CMD18: GPU1.K24 VRAM3.H11 VRAM4.K11
FBA_CMD19: GPU1.K23 VRAM3.K11 VRAM4.H11
FBA_CMD20: GPU1.M27 VRAM3.K10 VRAM4.H10
FBA_CMD21: GPU1.M26 VRAM3.L12 VRAM4.G12
FBA_CMD22: GPU1.M25 VRAM3.K4 VRAM4.H4
FBA_CMD23: GPU1.K26 VRAM3.K5 VRAM4.H5
FBA_CMD24: GPU1.K22 VRAM3.J4 VRAM4.J4
FBA_CMD25: GPU1.J23 VRAM3.J5 VRAM4.J5
FBA_CMD26: GPU1.J25 VRAM3.H4 VRAM4.K4
FBA_CMD27: GPU1.J24 VRAM3.H5 VRAM4.K5
FBA_CMD28: GPU1.K27 VRAM3.G3 VRAM4.L3
FBA_CMD29: GPU1.K25 R7821.2 VRAM3.J2 VRAM4.J2
FBA_CMD30: GPU1.J27 R7824.1 VRAM3.J3 VRAM4.J3
FBA_CMD31: GPU1.J26 VRAM3.L3 VRAM4.G3
FBA_D0: GPU1.E18 VRAM1.A4
FBA_D1: GPU1.F18 VRAM1.A2
FBA_D2: GPU1.E16 VRAM1.B4
FBA_D3: GPU1.F17 VRAM1.B2
FBA_D4: GPU1.D20 VRAM1.E4
FBA_D5: GPU1.D21 VRAM1.E2
FBA_D6: GPU1.F20 VRAM1.F4
FBA_D7: GPU1.E21 VRAM1.F2
FBA_D8: GPU1.E15 VRAM2.U11
FBA_D9: GPU1.D15 VRAM2.U13
FBA_D10: GPU1.F15 VRAM2.T11
FBA_D11: GPU1.F13 VRAM2.T13
FBA_D12: GPU1.C13 VRAM2.N11
FBA_D13: GPU1.B13 VRAM2.M11
FBA_D14: GPU1.E13 VRAM2.M13
FBA_D15: GPU1.D13 VRAM2.N13
FBA_D16: GPU1.B15 VRAM1.U11
FBA_D17: GPU1.C16 VRAM1.T13
FBA_D18: GPU1.A13 VRAM1.T11
FBA_D19: GPU1.A15 VRAM1.U13
FBA_D20: GPU1.B18 VRAM1.M13
FBA_D21: GPU1.A18 VRAM1.N13
FBA_D22: GPU1.A19 VRAM1.N11
FBA_D23: GPU1.C19 VRAM1.M11
FBA_D24: GPU1.B24 VRAM2.A4
FBA_D25: GPU1.C23 VRAM2.A2
FBA_D26: GPU1.A25 VRAM2.B4
FBA_D27: GPU1.A24 VRAM2.B2
FBA_D28: GPU1.A21 VRAM2.E4
FBA_D29: GPU1.B21 VRAM2.E2
FBA_D30: GPU1.C20 VRAM2.F4
FBA_D31: GPU1.C21 VRAM2.F2
FBA_D32: GPU1.R22 VRAM3.A4
FBA_D33: GPU1.R24 VRAM3.A2
FBA_D34: GPU1.T22 VRAM3.B4
FBA_D35: GPU1.R23 VRAM3.B2
FBA_D36: GPU1.N25 VRAM3.E4
FBA_D37: GPU1.N26 VRAM3.E2
FBA_D38: GPU1.N23 VRAM3.F4
FBA_D39: GPU1.N24 VRAM3.F2
FBA_D40: GPU1.V23 VRAM4.U11
FBA_D41: GPU1.V22 VRAM4.U13
FBA_D42: GPU1.T23 VRAM4.T11
FBA_D43: GPU1.U22 VRAM4.T13
FBA_D44: GPU1.Y24 VRAM4.N13
FBA_D45: GPU1.AA24 VRAM4.N11
FBA_D46: GPU1.Y22 VRAM4.M13
FBA_D47: GPU1.AA23 VRAM4.M11
FBA_D48: GPU1.AD27 VRAM3.T11
FBA_D49: GPU1.AB25 VRAM3.U13
FBA_D50: GPU1.AD26 VRAM3.U11
FBA_D51: GPU1.AC25 VRAM3.T13
FBA_D52: GPU1.AA27 VRAM3.M13
FBA_D53: GPU1.AA26 VRAM3.N13
FBA_D54: GPU1.W26 VRAM3.M11
FBA_D55: GPU1.Y25 VRAM3.N11
FBA_D56: GPU1.R26 VRAM4.A4
FBA_D57: GPU1.T25 VRAM4.A2
FBA_D58: GPU1.N27 VRAM4.B4
FBA_D59: GPU1.R27 VRAM4.B2
FBA_D60: GPU1.V26 VRAM4.E2
FBA_D61: GPU1.V27 VRAM4.E4
FBA_D62: GPU1.W27 VRAM4.F2
FBA_D63: GPU1.W25 VRAM4.F4
FBA_DEBUG0: GPU1.F22 R7803.1
FBA_DEBUG1: GPU1.J22 R7804.1
FBA_DQM0: GPU1.D19 VRAM1.D2
FBA_DQM1: GPU1.D14 VRAM2.P13
FBA_DQM2: GPU1.C17 VRAM1.P13
FBA_DQM3: GPU1.C22 VRAM2.D2
FBA_DQM4: GPU1.P24 VRAM3.D2
FBA_DQM5: GPU1.W24 VRAM4.P13
FBA_DQM6: GPU1.AA25 VRAM3.P13
FBA_DQM7: GPU1.U25 VRAM4.D2
FBA_EDC0: GPU1.E19 VRAM1.C2
FBA_EDC1: GPU1.C15 VRAM2.R13
FBA_EDC2: GPU1.B16 VRAM1.R13
FBA_EDC3: GPU1.B22 VRAM2.C2
FBA_EDC4: GPU1.R25 VRAM3.C2
FBA_EDC5: GPU1.W23 VRAM4.R13
FBA_EDC6: GPU1.AB26 VRAM3.R13
FBA_EDC7: GPU1.T26 VRAM4.C2
FBA_MF1: R8111.2 VRAM1.J1
FBA_MF2: R8112.1 VRAM2.J1
FBA_MF3: R8211.2 VRAM3.J1
FBA_MF4: R8210.1 VRAM4.J1
FBA_SEN0: R8110.2 VRAM1.J10 VRAM2.J10
FBA_SEN2: R8209.2 VRAM3.J10 VRAM4.J10
FBA_VREF_FET_H: Q8201.D R8202.2
FBA_VREF_FET_L: Q8101.D R8104.2
FBA_VREFC0: C8103.1 R8104.1 R8106.2 R8107.1 VRAM1.J14 VRAM2.J14
FBA_VREFC1: C8202.1 R8202.1 R8203.2 R8204.1 VRAM3.J14 VRAM4.J14
FBA_WCK01: GPU1.D18 VRAM1.D4 VRAM2.P4
FBA_WCK01#: GPU1.C18 VRAM1.D5 VRAM2.P5
FBA_WCK23: GPU1.D17 VRAM1.P4 VRAM2.D4
FBA_WCK23#: GPU1.D16 VRAM1.P5 VRAM2.D5
FBA_WCK45: GPU1.T24 VRAM3.D4 VRAM4.P4
FBA_WCK45#: GPU1.U24 VRAM3.D5 VRAM4.P5
FBA_WCK67: GPU1.V24 VRAM3.P4 VRAM4.D4
FBA_WCK67#: GPU1.V25 VRAM3.P5 VRAM4.D5
FBA_ZQ0: R8108.1 VRAM1.J13
FBA_ZQ1: R8113.1 VRAM2.J13
FBA_ZQ2: R8212.1 VRAM3.J13
FBA_ZQ3: R8213.1 VRAM4.J13
FFS_INT1: CPU1.CG22 U7001.12
FFS_INT2: CPU1.CH12 Q7001.5 R2044.2 R7011.1 U7001.11
FFS_INT2_Q: HDD1.9 HDD2.12 Q7001.6 R7014.2
FLT_NXP3290: R7414.2 U7403.A4
FP1_USB20_CON_N: ED9202.6 FP1.3 R9209.1
FP1_USB20_CON_P: ED9202.1 FP1.4 R9210.1
FP1_USB20_N: CPU1.CG5 R9209.2
FP1_USB20_P: CPU1.CG6 R9210.2
FP_3D3V: AFTP9201.1 C9201.1 C9202.1 ED9202.5 FP1.1 Q9201.D R9201.1 R9211.1
FP_EN#: C9203.1 Q9201.G Q9202.D R9212.2
FPR_SCAN#: AFTP9204.1 FP1.7 R9201.2 U2401.42
GC6_FB_EN_GPU: Q7907.2 R7916.2 R7927.1 R7959.2 R7975.1
GC6_FB_EN_GPU_L: Q7907.5 Q7907.6 R7952.1
GC6_FB_EN_GPU_R: GPU1.B2 R7916.1
GC6_FB_EN_MCP: CPU1.CE28 Q7907.3 R7953.2 R7975.2 U8803.2
GC6_THM_DIS: R2490.2 U2401.23
GC6_THM_DIS#_EC: R2426.2 R2471.2
GC6_THM_DIS#_PCH: CPU1.CL35 R2490.1
GFX_CLK_CPU_N: CPU1.AW2 GPU1.AD8
GFX_CLK_CPU_P: CPU1.AY3 GPU1.AE8
GFX_PCIE_RX_N0: C7602.1 CPU1.BW9
GFX_PCIE_RX_N1: C7604.1 CPU1.BU6
GFX_PCIE_RX_N2: C7606.1 CPU1.BT7
GFX_PCIE_RX_N3: C7608.1 CPU1.BU9
GFX_PCIE_RX_P0: C7601.1 CPU1.BW8
GFX_PCIE_RX_P1: C7603.1 CPU1.BU5
GFX_PCIE_RX_P2: C7605.1 CPU1.BT6
GFX_PCIE_RX_P3: C7607.1 CPU1.BU8
GFX_PCIE_TX_C_N0: C1606.2 CPU1.BW4
GFX_PCIE_TX_C_N1: C1608.2 CPU1.BU4
GFX_PCIE_TX_C_N2: C1603.2 CPU1.BU2
GFX_PCIE_TX_C_N3: C1612.2 CPU1.BT4
GFX_PCIE_TX_C_P0: C1605.2 CPU1.BW3
GFX_PCIE_TX_C_P1: C1607.2 CPU1.BU3
GFX_PCIE_TX_C_P2: C1604.2 CPU1.BU1
GFX_PCIE_TX_C_P3: C1611.2 CPU1.BT3
GFX_PCIE_TX_N0: C1606.1 GPU1.AG7
GFX_PCIE_TX_N1: C1608.1 GPU1.AE7
GFX_PCIE_TX_N2: C1603.1 GPU1.AF9
GFX_PCIE_TX_N3: C1612.1 GPU1.AG10
GFX_PCIE_TX_P0: C1605.1 GPU1.AG6
GFX_PCIE_TX_P1: C1607.1 GPU1.AF7
GFX_PCIE_TX_P2: C1604.1 GPU1.AE9
GFX_PCIE_TX_P3: C1611.1 GPU1.AG9
GPCPLL_AVDD: C8047.1 C8048.1 C8051.1 GPU1.F11 R8003.2
GPD11/LANPHYPC: CPU1.BU34 R1721.2
GPD_7: CPU1.BV35 R1524.2
GPIO5_FRAME_LOCK#: GPU1.A3 R7963.1
GPIO6_VGA_CORE_PSI: GPU1.A4 R7965.1 R7966.1
GPIO9_ALERT: GPU1.F8 RN7910.2(A)
GPIO10_FBVREF: GPU1.C5 Q8101.G Q8201.G R7910.1
GPIO11_LCD_VDD: GPU1.E7 R7961.1
GPIO13_LCD_BLEN: GPU1.B4 R7913.1
GPP_E23_STRAP: CPU1.CN4 TP402.1
GPP_H1_SFRM: CPU1.CJ32 R1913.2
GPP_H2_CLKREQ0: CPU1.CH29 R1912.2
GPP_H21: CPU1.CF25 R1522.2
GPP_H23: CPU1.CM26 R1513.2
GPPC_H18_VCCIO_LPM: CPU1.CN27 R4034.1
GPU_CLKREQ#: GPU1.AC6 Q7601.S R7603.1
GPU_EVENT_GPU#: Q7906.S R7949.1 R7964.2 R7965.2
GPU_EVENT_GPU#_R: GPU1.D6 R7964.1
GPU_EVENT_MCP#: CPU1.CC27 Q7906.D R7948.1
GPU_I2C: R7912.1 R7923.2 RN7904.1(A) RN7904.2(A) RN7905.1(A) RN7905.2(A)
GPU_I2CA_SCL: GPU1.B7 RN7701.1(A)
GPU_I2CA_SDA: GPU1.A7 RN7701.2(A)
GPU_PEX_RST#: GPU1.AC7 R7613.2 R7614.1 U7602.4
GPU_PEX_RST_HOLD: R7931.2 R7973.2 U7602.1
GPU_PEX_RST_HOLD_GPU#: GPU1.C4 R7973.1
GPU_PWR_LEVEL: D7902.K PQ4402.D U2401.10
GPU_ROM: R7918.1 R7920.1 R7935.1 R7946.1 R7947.1
GPU_ROM_SCLK: GPU1.C12 R7920.2 R7921.1
GPU_ROM_SI: GPU1.B12 R7924.1 R7935.2
GPU_ROM_SO: GPU1.A12 R7918.2 R7932.1
GPU_THM_SMBCLK: Q5801.3 R2459.2 R2460.2 U2401.12
GPU_THM_SMBDAT: Q5801.6 R2447.2 R2455.2 U2401.11
GSENSOR_CS: R7006.1 U7001.2
GSENSOR_SDO: R7007.2 U7001.3
H_CPUPWRGD: CPU1.AR2 ED301.2 R1714.1
H_PECI: C2405.1 R2437.1 U2401.94
HDA_BITCLK_CODEC: EC1901.2 EC2706.1 ER2701.1 R1920.1
HDA_BITCLK_CODEC_R: ER2701.2 HDA27.5
HDA_BITCLK_CPU: CPU1.BN37 R1920.2
HDA_CODEC_SDIN0: HDA27.7 R2724.2
HDA_RST_N_CPU: CPU1.BL35 TP1901.1
HDA_SDIN0_CPU: CPU1.BN35 R2724.1
HDA_SDOUT_CODEC: EC1903.1 HDA27.4 R1921.1
HDA_SDOUT_CPU: CPU1.BN36 R1512.2 R1909.2 R1921.2
HDA_SPKR_R: D2703.1 R2740.2
HDA_SYNC_CODEC: HDA27.9 R1908.1
HDA_SYNC_CPU: CPU1.BN34 R1908.2
HDD2_SATA_RX_CON_N: C6030.2 HDD1.16 HDD2.5
HDD2_SATA_RX_CON_P: C6031.2 HDD1.15 HDD2.6
HDD2_SATA_TX_CON_N: C6029.2 HDD1.18 HDD2.3
HDD2_SATA_TX_CON_P: C6028.2 HDD1.19 HDD2.2
HDD_DET#: CPU1.CG20 HDD1.6 R2047.2
HDD_DEVSLP: CPU1.CP8 R6002.1
HDD_DEVSLP_R: HDD1.13 HDD2.8 R6002.2
HDD_SATA_RX_N11: C6030.1 CPU1.BN10 ED6001.4 ED6001.7
HDD_SATA_RX_P11: C6031.1 CPU1.BN8 ED6001.5 ED6001.6
HDD_SATA_TX_N11: C6029.1 CPU1.BN4 ED6001.2 ED6001.9
HDD_SATA_TX_P11: C6028.1 CPU1.BN3 ED6001.1 ED6001.10
HDMI_DDI_TX_CMC_N0: C5781.2 EL5703.1 R5770.1 R5775.1
HDMI_DDI_TX_CMC_N1: C5779.2 EL5702.1 R5768.1 R5773.1
HDMI_DDI_TX_CMC_N2: C5777.2 EL5701.1 R5705.1 R5766.1
HDMI_DDI_TX_CMC_N3: C5724.2 C5783.2 EL5704.1 R5772.1 R5777.1
HDMI_DDI_TX_CMC_P0: C5782.2 EL5703.2 R5769.1 R5776.1
HDMI_DDI_TX_CMC_P1: C5780.2 EL5702.2 R5767.1 R5774.1
HDMI_DDI_TX_CMC_P2: C5778.2 EL5701.2 R5759.1 R5765.1
HDMI_DDI_TX_CMC_P3: C5724.1 C5784.2 EL5704.2 R5771.1 R5778.1
HDMI_DDI_TX_CON_N0: ED5702.4 ED5702.7 EL5703.4 ER5703.2 HDMI1.9 R5770.2
HDMI_DDI_TX_CON_N1: ED5701.5 ED5701.6 EL5702.4 ER5702.2 HDMI1.6 R5768.2
HDMI_DDI_TX_CON_N2: ED5701.2 ED5701.9 EL5701.4 ER5701.2 HDMI1.3 R5766.2
HDMI_DDI_TX_CON_N3: ED5702.1 ED5702.10 EL5704.4 ER5704.2 HDMI1.12 R5772.2
HDMI_DDI_TX_CON_P0: ED5702.5 ED5702.6 EL5703.3 ER5703.1 HDMI1.7 R5769.2
HDMI_DDI_TX_CON_P1: ED5701.4 ED5701.7 EL5702.3 ER5702.1 HDMI1.4 R5767.2
HDMI_DDI_TX_CON_P2: ED5701.1 ED5701.10 EL5701.3 ER5701.1 HDMI1.1 R5765.2
HDMI_DDI_TX_CON_P3: ED5702.2 ED5702.9 EL5704.3 ER5704.1 HDMI1.10 R5771.2
HDMI_DDI_TX_N0: C5777.1 CPU1.AL5
HDMI_DDI_TX_N1: C5779.1 CPU1.AJ5
HDMI_DDI_TX_N2: C5781.1 CPU1.AF6
HDMI_DDI_TX_N3: C5783.1 CPU1.AE5
HDMI_DDI_TX_P0: C5778.1 CPU1.AL6
HDMI_DDI_TX_P1: C5780.1 CPU1.AJ6
HDMI_DDI_TX_P2: C5782.1 CPU1.AF5
HDMI_DDI_TX_P3: C5784.1 CPU1.AE6
HDMI_HPD_B: Q5703.B R5781.1
HDMI_HPD_CON: ED5703.5 ED5703.6 HDMI1.19 R5764.1 R5781.2
HDMI_PLL_GND: Q5701.D R5705.2 R5759.2 R5773.2 R5774.2 R5775.2 R5776.2 R5777.2 R5778.2
HDMI_SCL_CON: ED5703.1 ED5703.10 HDMI1.15 Q5702.3 R5755.2
HDMI_SCL_R: D5701.2 R5755.1
HDMI_SDA_CON: ED5703.2 ED5703.9 HDMI1.16 Q5702.6 R5751.2
HDMI_SDA_R: D5701.1 R5751.1
HOST_DEBUG_TX: DBEC1.5 R2480.1 R6801.1 U2401.81
HOST_DEBUG_TX_CON: DBG1.11 R6801.2
HPDIN: R7176.1 R7190.2 U7101.32
HW_ACAV_IN: D6403.K PG4408.2 PQ4415.5 R4482.1 U2401.128
HW_ACAV_IN0: Q4449.2 R4481.1 R4482.2
HW_ACAVIN_NB: D4305.A R4311.2 R4315.2 R4378.2 R4471.2 U2401.24 U4302.1
HW_ACAVIN_NB0: Q4449.5 R4470.1 R4471.1
I2C0_SCL_TCH_PAD: CPU1.CN11 EC6504.1 Q6504.1 R2066.2 R6505.1
I2C0_SCL_TCH_PNL: AFTP5504.1 CPU1.CJ12 LCD1.15 R5518.2
I2C0_SDA_TCH_PAD: CPU1.CM11 EC6502.1 Q6504.4 R2065.2 R6506.1
I2C0_SDA_TCH_PNL: AFTP5505.1 CPU1.CK12 LCD1.16 R5517.2
I2C1_SCL_R: AFTP6528.1 Q6504.6 R6505.2 RN6503.3(B) TP1.6
I2C1_SDA_R: AFTP6527.1 Q6504.3 R6506.2 RN6503.4(B) TP1.7
I2C_CLK: Q5801.4 R5834.2 U5802.1
I2C_CLK_PD: R7114.2 RN7202.3(B) U7201.17
I2C_CLK_PD_MUX: R7114.1 U7101.21
I2C_CTL_EN: R5812.2 R5821.2 U5802.2
I2C_DATA_PD: R7116.2 RN7202.4(B) U7201.16
I2C_DATA_PD_MUX: R7116.1 U7101.22
I2C_SDA: Q5801.1 R5817.2 U5802.60
I2CB_SCL: GPU1.C9 RN7905.3(B)
I2CB_SDA: GPU1.C8 RN7905.4(B)
I2CC_SCL: GPU1.A9 RN7904.4(B)
I2CC_SDA: GPU1.B9 RN7904.3(B)
I2CEN: C7166.2 R7173.1 R7174.2 U7101.17
I_ADP: C2435.1 R2421.2 U2401.110
I_BATT: C2431.1 R2483.2 U2401.114
IC_DELAY: C4344.1 U4302.4
ICSP_CLK: DBEC1.2 U2401.101
ICSP_CLR: DBEC1.6 R2414.1 U2401.87
ICSP_DAT: DBEC1.3 U2401.102
ILIM_HI: R3604.2 U3601.16
ILIM_LO: R3603.2 U3601.15
ILIM_SEL: R3605.2 U3601.4
IN_AUX_N: C5854.2 U5802.25
IN_AUX_P: C5862.2 U5802.24
INPUT3VSEL: CPU1.BT27 R1520.2 R1521.1
INT#_ITE8010: R2438.1 WWAN1.12
IO_DB_DET#: AFTP6609.1 CPU1.CM14 R6602.1
IO_DB_DET#_EC: R5560.1 R6610.1 R6611.2 U2401.34
IO_DB_DET#_GPPG5: CPU1.CH35 R6608.1
IO_DB_DET#_R: IOBD1.2 R6602.2 R6608.2 R6609.2 R6610.2
IR_CAM_DET#: AFTP5506.1 CPU1.CM22 LCD1.18 R2046.2
ISOLATE#: R3109.2 R3113.1 U3101.20
IST_TRIG: CPU1.CP36 TP620.1
ITP_PMODE: CPU1.W4 TP618.1
JACK_PLUG: ED2911.1 HPMIC1.5 R2923.1
JACK_PLUG_DET: ED2912.2 HPMIC1.6 R2914.1
JGND: AFTP4302.1 DCIN1.1 DCIN1.2 DCIN1.3 EC4301.2 EC4302.2 EC4312.2 EC4313.2 EL4303.1 EL4304.1
JIO3_PCIE_WAKE#: AFTP6115.1 D1702.2 D2404.2 R1806.2 WLAN1.55
KB_BL_CTRL#: C6511.1 KBBL1.4 Q6501.D
KB_DET#: AFTP6567.1 CPU1.CM12 KB1.30 R2045.2
KB_LED_BL_DET: CPU1.CK36 R6507.1 R6508.1
KB_LED_DET_C: C6510.1 KBBL1.2 R6507.2
KB_LED_PWM: Q6501.G U2401.44
KBC_BEEP_R: D2703.2 R2739.2
KBC_PWRBTN#: FP1.2 Q6408.E R2432.1 RN6401.2(A)
KBC_PWRBTN#_C: AFTP6404.1 EC6403.1 ED6401.1 G6401.1 G6402.1 PWR1.2 RN6401.3(B)
KSI0: AFTP6548.1 KB1.22 RN2403.5(B) U2401.98
KSI1: AFTP6547.1 KB1.24 RN2403.7(B) U2401.99
KSI2: AFTP6545.1 KB1.26 RN2404.5(B) U2401.6
KSI3: AFTP6550.1 KB1.23 RN2403.6(B) U2401.7
KSI4: AFTP6544.1 KB1.27 RN2404.6(B) U2401.104
KSI5: AFTP6546.1 KB1.25 RN2403.8(B) U2401.105
KSI6: AFTP6543.1 KB1.28 RN2404.7(B) U2401.107
KSI7: AFTP6542.1 KB1.29 RN2404.8(B) U2401.108
KSO0: AFTP6557.1 KB1.13 RN2410.5(B) U2401.2
KSO1: AFTP6558.1 KB1.15 RN2412.8(B) U2401.14
KSO2: AFTP6556.1 KB1.14 RN2412.7(B) U2401.15
KSO3: AFTP6555.1 KB1.16 RN2409.5(B) U2401.16
KSO4: AFTP6551.1 KB1.20 RN2407.3(B) U2401.37
KSO5: AFTP6549.1 KB1.21 RN2407.4(B) U2401.38
KSO6: AFTP6553.1 KB1.18 RN2409.7(B) U2401.39
KSO7: AFTP6552.1 KB1.19 RN2409.8(B) U2401.50
KSO8: AFTP6554.1 KB1.17 RN2409.6(B) U2401.46
KSO9: AFTP6563.1 KB1.7 R2449.2 R2450.1 U2401.68
KSO10: AFTP6566.1 KB1.5 RN2411.3(B) U2401.72
KSO11: AFTP6565.1 KB1.6 RN2411.4(B) U2401.74
KSO12: AFTP6559.1 KB1.12 RN2412.6(B) U2401.75
KSO13: AFTP6562.1 KB1.9 RN2410.7(B) U2401.76
KSO14: AFTP6564.1 KB1.8 RN2410.6(B) U2401.77
KSO15: AFTP6561.1 KB1.10 RN2410.8(B) U2401.86
KSO16: AFTP6560.1 KB1.11 RN2412.5(B) U2401.92
L_BKLT_CTRL: CPU1.CH11 D5503.1
L_BKLT_EN: CPU1.CK11 R2427.2 R2435.2 R2436.1 R2438.2
L_BKLT_EN_L: D2401.2 R2427.1
LAN_CABLE_DETECT_R_#: R3104.1 U3101.26
LAN_CLK_CPU_N: CPU1.BD3 U3101.16
LAN_CLK_CPU_P: CPU1.BC3 U3101.15
LAN_LED0: Q3201.S R3203.1 U3101.27
LAN_LED0_Q: Q3201.D R3202.1 R3203.2
LAN_LED0_R: LED2.K R3202.2
LAN_MDI0_N: ED3201.2 ED3201.9 U3101.2 XF3202.8
LAN_MDI0_P: ED3201.1 ED3201.10 U3101.1 XF3202.7
LAN_MDI1_N: ED3201.5 ED3201.6 U3101.5 XF3202.12
LAN_MDI1_P: ED3201.4 ED3201.7 U3101.4 XF3202.11
LAN_MDI2_N: ED3202.2 ED3202.9 U3101.7 XF3201.12
LAN_MDI2_P: ED3202.1 ED3202.10 U3101.6 XF3201.11
LAN_MDI3_N: ED3202.5 ED3202.6 U3101.10 XF3201.8
LAN_MDI3_P: ED3202.4 ED3202.7 U3101.9 XF3201.7
LAN_PCIE_RX_C_N: C3107.2 U3101.18
LAN_PCIE_RX_C_P: C3102.2 U3101.17
LAN_PCIE_RX_N: C3107.1 CPU1.BP5
LAN_PCIE_RX_P: C3102.1 CPU1.BP6
LAN_PCIE_TX_N: C3109.1 CPU1.BR2
LAN_PCIE_TX_N_C: C3109.2 U3101.14
LAN_PCIE_TX_P: C3104.1 CPU1.BR1
LAN_PCIE_TX_P_C: C3104.2 U3101.13
LAN_WAKE#: CPU1.BU32 R1707.2
LANWAKE#: R2428.2 U2401.35
LANXIN: C3125.1 U3101.28 X3101.1
LANXOUT: C3116.1 U3101.29 X3101.3
LCD_BRIGHTNESS: LCD1.31 RN5503.6(B)
LCD_CBL_DET#: AFTP5517.1 CPU1.CN14 LCD1.29 R2060.2
LCD_TST: D5503.2 RN5503.2(A) U2401.26
LCD_TST_C: LCD1.32 RN5503.7(B)
LCD_VCC_TEST_EN: D5502.2 U2401.113
LCDVDD_EN: D5502.3 RN5502.3(A) U5501.4
LCDVDD_PG: Q5504.1 R5548.2
LCDVDD_PWRGD: C5535.1 D5505.K R5552.1 R5553.1
LDO1_CAP: C2703.1 HDA27.21 R2702.1
LDO2_CAP: C2711.1 HDA27.32
LDO3_CAP: C2722.1 HDA27.6
LID_CL_SIO#: D2402.K FP1.6 R2498.2 RN6401.1(A) U2401.66 U2402.2
LID_CLOSE#_C: AFTP6401.1 EC6401.1 ED6401.2 PWR1.3 RN6401.4(B)
LINE1-L_C: C2907.2 R2922.1
LINE1-L_R: C2908.2 R2921.1
LINE1_L: C2907.1 HDA27.18
LINE1_R: C2908.1 HDA27.17
LINE1_VREFO: D2901.3 HDA27.24
LINE1_VREFO_D1: D2901.1 R2912.1
LINE1_VREFO_D2: D2901.2 R2913.1
LOM_CABLE_DETECT#: CPU1.CK34 R3104.2
LOM_TCT: C3203.1 XF3201.9 XF3201.10 XF3202.9 XF3202.10
LPS_SW: C7401.2 R7401.2 R7403.1 R7407.1 U7418.4
LPS_SW_A: Q7406.3 R7401.1
LPS_SW_C: Q7401.G R7406.2 R7408.1
LPS_SW_D: Q7406.6 R7408.2
LPS_SW_R: Q7401.D R7403.2
M2_PCIE_LED#: D6401.2 R6411.2 SSD1.10
M2_SSD_PEDET: CPU1.CP10 R6348.2 SSD1.69
M_A_A0: CPU1.AC37 DM1.144
M_A_A1: CPU1.AC36 DM1.133
M_A_A2: CPU1.AC34 DM1.132
M_A_A3: CPU1.AC35 DM1.131
M_A_A4: CPU1.AA35 DM1.128
M_A_A5: CPU1.AB35 DM1.126
M_A_A6: CPU1.AA37 DM1.127
M_A_A7: CPU1.AA36 DM1.122
M_A_A8: CPU1.AB34 DM1.125
M_A_A9: CPU1.W36 DM1.121
M_A_A10: CPU1.Y31 DM1.146
M_A_A11: CPU1.W34 DM1.120
M_A_A12: CPU1.AA34 DM1.119
M_A_A13: CPU1.AC32 DM1.158
M_A_A14: CPU1.AC31 DM1.151
M_A_A15: CPU1.AB32 DM1.156
M_A_A16: CPU1.Y32 DM1.152
M_A_ACT_N: CPU1.V35 DM1.114
M_A_ALERT_N: CPU1.W37 DM1.116
M_A_BA0: CPU1.W32 DM1.150
M_A_BA1: CPU1.AB31 DM1.145
M_A_BG0: CPU1.V34 DM1.115
M_A_BG1: CPU1.W35 DM1.113
M_A_CKE0: CPU1.U36 DM1.109
M_A_CKE1: CPU1.U37 DM1.110
M_A_CLK0: CPU1.V31 DM1.137
M_A_CLK1: CPU1.T31 DM1.138
M_A_CLK#0: CPU1.V32 DM1.139
M_A_CLK#1: CPU1.T32 DM1.140
M_A_CS#0: CPU1.AE32 DM1.149
M_A_CS#1: CPU1.AF32 DM1.157
M_A_DIMA_ODT0: CPU1.AE31 DM1.155
M_A_DIMA_ODT1: CPU1.AF31 DM1.161
M_A_DQ0: CPU1.A26 DM1.28
M_A_DQ1: CPU1.D26 DM1.37
M_A_DQ2: CPU1.D28 DM1.42
M_A_DQ3: CPU1.C28 DM1.24
M_A_DQ4: CPU1.B26 DM1.25
M_A_DQ5: CPU1.C26 DM1.29
M_A_DQ6: CPU1.B28 DM1.38
M_A_DQ7: CPU1.A28 DM1.41
M_A_DQ8: CPU1.B30 DM1.49
M_A_DQ9: CPU1.D30 DM1.46
M_A_DQ10: CPU1.B33 DM1.62
M_A_DQ11: CPU1.D32 DM1.58
M_A_DQ12: CPU1.A30 DM1.50
M_A_DQ13: CPU1.C30 DM1.45
M_A_DQ14: CPU1.B32 DM1.59
M_A_DQ15: CPU1.C32 DM1.63
M_A_DQ16: CPU1.J22 DM1.66
M_A_DQ17: CPU1.H25 DM1.80
M_A_DQ18: CPU1.G22 DM1.67
M_A_DQ19: CPU1.H22 DM1.70
M_A_DQ20: CPU1.F25 DM1.83
M_A_DQ21: CPU1.J25 DM1.84
M_A_DQ22: CPU1.G25 DM1.79
M_A_DQ23: CPU1.F22 DM1.71
M_A_DQ24: CPU1.D22 DM1.7
M_A_DQ25: CPU1.C22 DM1.8
M_A_DQ26: CPU1.C24 DM1.17
M_A_DQ27: CPU1.D24 DM1.21
M_A_DQ28: CPU1.A22 DM1.4
M_A_DQ29: CPU1.B22 DM1.3
M_A_DQ30: CPU1.A24 DM1.16
M_A_DQ31: CPU1.B24 DM1.20
M_A_DQ32: CPU1.H37 DM1.211
M_A_DQ33: CPU1.H34 DM1.212
M_A_DQ34: CPU1.K34 DM1.229
M_A_DQ35: CPU1.K35 DM1.228
M_A_DQ36: CPU1.H36 DM1.216
M_A_DQ37: CPU1.H35 DM1.215
M_A_DQ38: CPU1.K36 DM1.224
M_A_DQ39: CPU1.K37 DM1.225
M_A_DQ40: CPU1.N36 DM1.236
M_A_DQ41: CPU1.N34 DM1.237
M_A_DQ42: CPU1.R37 DM1.246
M_A_DQ43: CPU1.R34 DM1.250
M_A_DQ44: CPU1.N37 DM1.232
M_A_DQ45: CPU1.N35 DM1.233
M_A_DQ46: CPU1.R36 DM1.245
M_A_DQ47: CPU1.R35 DM1.249
M_A_DQ48: CPU1.G31 DM1.183
M_A_DQ49: CPU1.G32 DM1.182
M_A_DQ50: CPU1.H29 DM1.169
M_A_DQ51: CPU1.H28 DM1.174
M_A_DQ52: CPU1.G28 DM1.170
M_A_DQ53: CPU1.G29 DM1.173
M_A_DQ54: CPU1.H31 DM1.186
M_A_DQ55: CPU1.H32 DM1.187
M_A_DQ56: CPU1.L31 DM1.195
M_A_DQ57: CPU1.L32 DM1.194
M_A_DQ58: CPU1.N29 DM1.204
M_A_DQ59: CPU1.N28 DM1.208
M_A_DQ60: CPU1.L28 DM1.191
M_A_DQ61: CPU1.L29 DM1.190
M_A_DQ62: CPU1.N31 DM1.203
M_A_DQ63: CPU1.N32 DM1.207
M_A_DQS_DN0: CPU1.C27 DM1.32
M_A_DQS_DN1: CPU1.D31 DM1.53
M_A_DQS_DN2: CPU1.H24 DM1.74
M_A_DQS_DN3: CPU1.C23 DM1.11
M_A_DQS_DN4: CPU1.J35 DM1.219
M_A_DQS_DN5: CPU1.P34 DM1.240
M_A_DQS_DN6: CPU1.G30 DM1.177
M_A_DQS_DN7: CPU1.L30 DM1.198
M_A_DQS_DP0: CPU1.D27 DM1.34
M_A_DQS_DP1: CPU1.C31 DM1.55
M_A_DQS_DP2: CPU1.G24 DM1.76
M_A_DQS_DP3: CPU1.D23 DM1.13
M_A_DQS_DP4: CPU1.J34 DM1.221
M_A_DQS_DP5: CPU1.P35 DM1.242
M_A_DQS_DP6: CPU1.H30 DM1.179
M_A_DQS_DP7: CPU1.N30 DM1.200
M_A_PARITY: CPU1.W31 DM1.143
M_B_A0: CPU1.AG36 DM2.144
M_B_A1: CPU1.AG35 DM2.133
M_B_A2: CPU1.AF34 DM2.132
M_B_A3: CPU1.AG37 DM2.131
M_B_A4: CPU1.AE35 DM2.128
M_B_A5: CPU1.AF35 DM2.126
M_B_A6: CPU1.AE37 DM2.127
M_B_A7: CPU1.AC29 DM2.122
M_B_A8: CPU1.AE36 DM2.125
M_B_A9: CPU1.AB29 DM2.121
M_B_A10: CPU1.AG34 DM2.146
M_B_A11: CPU1.AC28 DM2.120
M_B_A12: CPU1.AB28 DM2.119
M_B_A13: CPU1.AK35 DM2.158
M_B_A14: CPU1.AJ35 DM2.151
M_B_A15: CPU1.AK34 DM2.156
M_B_A16: CPU1.AJ34 DM2.152
M_B_ACT_N: CPU1.W28 DM2.114
M_B_ALERT_N: CPU1.Y29 DM2.116
M_B_BA0: CPU1.AJ37 DM2.150
M_B_BA1: CPU1.AJ36 DM2.145
M_B_BG0: CPU1.W29 DM2.115
M_B_BG1: CPU1.Y28 DM2.113
M_B_CKE0: CPU1.T28 DM2.109
M_B_CKE1: CPU1.T29 DM2.110
M_B_CLK0: CPU1.AF29 DM2.137
M_B_CLK1: CPU1.AE29 DM2.138
M_B_CLK#0: CPU1.AF28 DM2.139
M_B_CLK#1: CPU1.AE28 DM2.140
M_B_CS#0: CPU1.AL37 DM2.149
M_B_CS#1: CPU1.AL35 DM2.157
M_B_DIMB_ODT0: CPU1.AL36 DM2.155
M_B_DIMB_ODT1: CPU1.AL34 DM2.161
M_B_DQ0: CPU1.AN35 DM2.3
M_B_DQ1: CPU1.AN34 DM2.8
M_B_DQ2: CPU1.AR35 DM2.17
M_B_DQ3: CPU1.AR34 DM2.16
M_B_DQ4: CPU1.AN37 DM2.7
M_B_DQ5: CPU1.AN36 DM2.4
M_B_DQ6: CPU1.AR36 DM2.20
M_B_DQ7: CPU1.AR37 DM2.21
M_B_DQ8: CPU1.AU35 DM2.25
M_B_DQ9: CPU1.AU34 DM2.24
M_B_DQ10: CPU1.AW35 DM2.37
M_B_DQ11: CPU1.AW34 DM2.38
M_B_DQ12: CPU1.AU37 DM2.29
M_B_DQ13: CPU1.AU36 DM2.28
M_B_DQ14: CPU1.AW36 DM2.41
M_B_DQ15: CPU1.AW37 DM2.42
M_B_DQ16: CPU1.AJ29 DM2.46
M_B_DQ17: CPU1.AJ30 DM2.49
M_B_DQ18: CPU1.AM32 DM2.59
M_B_DQ19: CPU1.AM31 DM2.62
M_B_DQ20: CPU1.AM30 DM2.63
M_B_DQ21: CPU1.AM29 DM2.58
M_B_DQ22: CPU1.AJ31 DM2.45
M_B_DQ23: CPU1.AJ32 DM2.50
M_B_DQ24: CPU1.AR31 DM2.71
M_B_DQ25: CPU1.AR32 DM2.70
M_B_DQ26: CPU1.AV30 DM2.83
M_B_DQ27: CPU1.AV29 DM2.84
M_B_DQ28: CPU1.AR30 DM2.66
M_B_DQ29: CPU1.AR29 DM2.67
M_B_DQ30: CPU1.AV32 DM2.80
M_B_DQ31: CPU1.AV31 DM2.79
M_B_DQ32: CPU1.BA35 DM2.173
M_B_DQ33: CPU1.BA34 DM2.170
M_B_DQ34: CPU1.BC35 DM2.187
M_B_DQ35: CPU1.BC34 DM2.183
M_B_DQ36: CPU1.BA37 DM2.169
M_B_DQ37: CPU1.BA36 DM2.174
M_B_DQ38: CPU1.BC36 DM2.186
M_B_DQ39: CPU1.BC37 DM2.182
M_B_DQ40: CPU1.BE35 DM2.195
M_B_DQ41: CPU1.BE34 DM2.191
M_B_DQ42: CPU1.BG35 DM2.207
M_B_DQ43: CPU1.BG34 DM2.194
M_B_DQ44: CPU1.BE37 DM2.204
M_B_DQ45: CPU1.BE36 DM2.190
M_B_DQ46: CPU1.BG36 DM2.203
M_B_DQ47: CPU1.BG37 DM2.208
M_B_DQ48: CPU1.BA32 DM2.211
M_B_DQ49: CPU1.BA31 DM2.215
M_B_DQ50: CPU1.BD31 DM2.225
M_B_DQ51: CPU1.BD32 DM2.224
M_B_DQ52: CPU1.BA30 DM2.216
M_B_DQ53: CPU1.BA29 DM2.212
M_B_DQ54: CPU1.BD29 DM2.228
M_B_DQ55: CPU1.BD30 DM2.229
M_B_DQ56: CPU1.BG31 DM2.233
M_B_DQ57: CPU1.BG32 DM2.237
M_B_DQ58: CPU1.BK32 DM2.246
M_B_DQ59: CPU1.BK31 DM2.245
M_B_DQ60: CPU1.BG29 DM2.232
M_B_DQ61: CPU1.BG30 DM2.236
M_B_DQ62: CPU1.BK30 DM2.250
M_B_DQ63: CPU1.BK29 DM2.249
M_B_DQS_DN0: CPU1.AP35 DM2.11
M_B_DQS_DN1: CPU1.AV34 DM2.32
M_B_DQS_DN2: CPU1.AL31 DM2.53
M_B_DQS_DN3: CPU1.AU31 DM2.74
M_B_DQS_DN4: CPU1.BB35 DM2.177
M_B_DQS_DN5: CPU1.BF34 DM2.198
M_B_DQS_DN6: CPU1.BC31 DM2.219
M_B_DQS_DN7: CPU1.BH31 DM2.240
M_B_DQS_DP0: CPU1.AP34 DM2.13
M_B_DQS_DP1: CPU1.AV35 DM2.34
M_B_DQS_DP2: CPU1.AL30 DM2.55
M_B_DQS_DP3: CPU1.AU30 DM2.76
M_B_DQS_DP4: CPU1.BB34 DM2.179
M_B_DQS_DP5: CPU1.BF35 DM2.200
M_B_DQS_DP6: CPU1.BC30 DM2.221
M_B_DQS_DP7: CPU1.BH30 DM2.242
M_B_PARITY: CPU1.AE34 DM2.143
M_VREF_CA_DIMMA: C1229.1 DM1.164 R1206.1 RN1201.3(B) RN1201.4(B)
M_VREF_CA_DIMMB: C1301.1 DM2.164 R1305.1 RN1301.3(B) RN1301.4(B)
MASK_SATA_LED#: Q6401.G R6403.2 U2401.56
MCT: C3202.1 RN3201.5(B) RN3201.6(B) RN3201.7(B) RN3201.8(B)
MCT0: RN3201.1(A) XF3201.3
MCT1: RN3201.2(A) XF3201.4
MCT2: RN3201.3(A) XF3202.3
MCT3: RN3201.4(A) XF3202.4
MDO0+: AFTP3204.1 RJ1.1 XF3202.6
MDO0-: AFTP3201.1 RJ1.2 XF3202.5
MDO1+: AFTP3202.1 RJ1.3 XF3202.2
MDO1-: AFTP3208.1 RJ1.6 XF3202.1
MDO2+: AFTP3205.1 RJ1.4 XF3201.2
MDO2-: AFTP3207.1 RJ1.5 XF3201.1
MDO3+: AFTP3209.1 RJ1.7 XF3201.6
MDO3-: AFTP3206.1 RJ1.8 XF3201.5
ME_FWP: AFTP6803.1 MESW1.3 R6878.1 U2401.80
ME_FWP_R: AFTP6802.1 MESW1.2 R1909.1 R6878.2
ME_SUS_PWR_ACK_R: CPU1.BV34 R1708.1 R1738.2
MEC_XTAL1_R: C2425.2 U2401.123 X2401.1
MEC_XTAL2: C2424.2 R2461.2 U2401.125 X2401.2
MEM_SMBCLK: CPU1.CK14 Q1801.3 RN1807.8(B)
MEM_SMBDATA: CPU1.CH15 Q1801.6 RN1807.5(B)
MESW1_B: AFTP6801.1 MESW1.1 R6804.1 R6877.1
MIC2_VREFO: HDA27.23 RN2901.1(A) RN2901.2(A)
MIC_CAP: C2715.1 HDA27.15
MODEL_ID: C2407.1 R2441.1 R2442.2 U2401.109
MSATA_DEVSLP_R: R6301.2 SSD1.38
MUX_CRT_AUX_CPU_N: R5825.2 U5802.29
MUX_CRT_AUX_CPU_P: R5824.2 U5802.28
MUX_HPD_PD: R7118.1 U7101.23
MUX_SAI: R7127.2 U7102.14
MUX_SAO: R7129.2 U7102.15
MUX_SBI: R7128.2 U7102.12
MUX_SBO: R7130.2 U7102.11
N12P_JTAG_TCK: GPU1.AE5 TP7903.1
N12P_JTAG_TDI: GPU1.AE6 TP7905.1
N12P_JTAG_TDO: GPU1.AF6 TP7901.1
N12P_JTAG_TMS: GPU1.AD6 TP7902.1
N12P_JTAG_TRST: GPU1.AG4 R7944.1
N12P_XTAL_OUTBUFF: GPU1.C10 R7902.1 R7917.2
NB_MUTE#: R2712.1 R2717.2 U2401.119
NC_AUX_EN_WOWL_EC: R2403.1 R2409.1 U2401.41
NCT7718_DXN: C2606.2 C2607.2 Q2603.E U2601.3
NCT7718_DXP: C2606.1 C2607.1 Q2603.B Q2603.C U2601.2
NRB_BIT: CPU1.CE29 R1502.2
NUVOTON_PP: TP9104.1 U9103.4
NVVDD_EN: C8802.1 R8801.2 R8809.1 U8804.2
NVVDD_EN_1: R8810.2 U8804.1
NXP3290_FO: R7402.1 U7201.23 U7403.C4
NXP3290_ILIM: R7418.1 U7403.A3
NXP3290CAP: C7405.1 U7403.D4
ODD_SATA_RX_CON_N: AFTP6003.1 C6010.2 ODD1.4
ODD_SATA_RX_CON_P: AFTP6004.1 C6011.2 ODD1.5
ODD_SATA_RX_N12: C6010.1 CPU1.BL6
ODD_SATA_RX_P12: C6011.1 CPU1.BL5
ODD_SATA_TX_CON_N: AFTP6002.1 C6013.2 ODD1.2
ODD_SATA_TX_CON_P: AFTP6001.1 C6014.2 ODD1.1
ODD_SATA_TX_N12: C6013.1 CPU1.BN2
ODD_SATA_TX_P12: C6014.1 CPU1.BN1
OUT1_CA_DET: R5818.1 U5802.43
OUT2_CA_DET: R5819.1 U5802.33
OVERT_GPU#: GPU1.A6 RN7910.1(A)
PANEL_BKEN: D2401.3 RN5502.1(A) RN5503.4(A)
PANEL_BKEN_EC: D2401.1 U2401.117
PANEL_MONITOR: R5545.1 U2401.97
PANEL_PWRGD_R: C5529.1 Q5504.3 Q5505.3 R5545.2 R5547.1 R5549.2
PBAT_CHG_SMBCLK: EC4309.1 ED4306.3 PU4401.22 RN2402.3(B) RN4302.2(A) U2401.9
PBAT_CHG_SMBDAT: EC4310.1 ED4305.3 PU4401.21 RN2402.4(B) RN4302.3(A) U2401.8
PBAT_PRES1#: AFTP4309.1 BATT1.6 RN4302.5(B)
PBAT_PRES#: EC4306.2 ED4304.3 PR4409.2 R2415.1 RN4302.4(A) U2401.29
PBAT_SMBCLK1: AFTP4311.1 BATT1.4 RN4302.7(B)
PBAT_SMBDAT1: AFTP4310.1 BATT1.5 RN4302.6(B)
PC10: R5807.2 R5808.2 U5802.56
PC11: R5811.2 U5802.55
PC20: R5809.2 R5810.2 U5802.54
PC21: R5813.2 R5814.2 U5802.53
PCH_BATLOW#: CPU1.BV36 RN1704.8(B)
PCH_ESPI_CLK: CPU1.BV32 R1805.1
PCH_ESPI_IO0: CPU1.CA29 RN1806.1(A)
PCH_ESPI_IO1: CPU1.BY29 RN1806.3(A)
PCH_ESPI_IO2: CPU1.BY27 RN1806.2(A)
PCH_ESPI_IO3: CPU1.BV27 RN1806.4(A)
PCH_JTAG_TCK: CPU1.W6 FC8983.1 R318.1
PCH_JTAG_TDI: CPU1.U5 R312.1
PCH_JTAG_TDO: CPU1.W5 R313.1
PCH_JTAG_TMS: CPU1.P5 R314.1
PCH_PLTRST#: CPU1.BJ35 R1713.2
PCH_POPIRCOMP: CPU1.BW25 R305.1
PCH_RSMRST#: EC1712.1 R1702.2 R6414.2 U2401.27
PCH_SMBCLK: DM1.253 DM2.253 FC9001.1 Q1801.4 RN1810.3(B) U7001.1 VGABD1.16
PCH_SMBDATA: DM1.254 DM2.254 Q1801.1 RN1810.4(B) U7001.4 VGABD1.17
PCH_TPAN_VDD_EN: CPU1.CC30 R5559.1
PCH_WAKE#: CPU1.BU30 D1702.3 R2428.1 RN1704.6(B)
PCIE_LAN_WAKE#: D1702.1 D2404.1 R3103.1 U3101.21
PCIE_RCOMPN: CPU1.CE6 R1604.1
