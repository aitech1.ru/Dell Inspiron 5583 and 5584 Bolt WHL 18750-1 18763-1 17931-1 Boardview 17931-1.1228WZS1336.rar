# Allegro board 17931-1.1228WZS1336.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_D53: length 32.9
  TOP w0.14: VRAM3.N13 v2(163.2,148.13)
  L3 w0.089: v2(163.2,148.13) 162.82,147.75 162.82,147.02 162.74,146.94 162.74,146.89
  L3 w0.114: v2(137.35,145.4) 138,145.4 138.83,146.22 151.78,146.22 153.46,144.55 161.77,144.55 162.36,145.14 162.36,146.51 162.74,146.89
  BOTTOM w0.14: v2(137.35,145.4) 137.35,145.19 136.92,144.76 136.92,144.09 136.6,143.77 136.6,143.2 GPU1.AA26
FBA_D54: length 36.2
  TOP w0.14: VRAM3.M11 v2(163.2,146.53)
  L3 w0.114: v2(138.94,145.55) 139.16,145.77 146.2,145.77 148.23,143.74 149.51,143.74 149.86,144.09 150.31,144.09 150.43,144.2 150.43,145.1 150.54,145.21 150.77,145.21 150.89,145.1 150.89,144.2 151,144.09 151.23,144.09 151.34,144.2 151.34,145.1 151.46,145.21 151.69,145.21 151.8,145.1 151.8,144.2 151.91,144.09 162.33,144.09 163.35,145.11 163.35,146.38 v2(163.2,146.53)
  BOTTOM w0.14: 137.66,141.89 137.49,142.06 137.49,143.04 138.94,144.48 v2(138.94,145.55)
FBA_D55: length 34.9
  TOP w0.14: VRAM3.N11 v2(164,147.33)
  L3 w0.089: v2(164,147.33) 164.39,146.94 164.39,145.9
  L3 w0.114: v2(135.94,141.95) 135.94,141.94 136.1,141.94 139.47,145.31 146.01,145.31 148.04,143.28 151.36,143.28 151.69,143.61 162.73,143.61 164.39,145.26 164.39,145.9
  BOTTOM w0.14: GPU1.Y25 136.47,141.95 v2(135.94,141.95)
FBA_D56: length 38.2
  L3 w0.114: v2(141.05,139.34) 141.31,139.08 144.48,139.08 150.33,133.23 164.8,133.23 168.02,136.45 168.02,140.92 v2(167.2,141.75)
  BOTTOM w0.14: VRAM4.A4 167.2,141.73 v2(167.2,141.75) ; GPU1.R26 140.82,139.57 v2(141.05,139.34)
FBA_D57: length 35.9
  L3 w0.114: v2(139.42,139.59) 140.23,139.59 140.39,139.75 141.33,139.75 141.64,139.75 141.77,139.63 144.58,139.63 150.52,133.68 164.38,133.68 167.57,136.87 167.57,137.29 167.67,137.39 167.67,138.86 v2(167.24,139.29)
  BOTTOM w0.14: VRAM4.A2 v2(167.24,139.29) ; GPU1.T25 138.87,139.59 v2(139.42,139.59)
FBA_D58: length 35.3
  L3 w0.114: v2(165.6,140.93) 166.52,140.01 166.52,137.52 163.6,134.6 150.9,134.6 144.15,141.35 143.04,141.35 v2(142.79,141.61)
  BOTTOM w0.14: VRAM4.B4 v2(165.6,140.93) ; GPU1.N27 141.73,139.84 142.79,140.89 v2(142.79,141.61)
FBA_D59: length 35.5
  L3 w0.089: 166.8,139.49 166.8,139.67 v2(167.24,140.11)
  L3 w0.114: 166.8,139.49 166.8,139.49 166.8,139.1 167.39,138.51 167.39,137.64 163.89,134.14 150.71,134.14 144.64,140.21 142.36,140.21 v2(141.91,140.66)
  BOTTOM w0.14: v2(141.91,140.66) 141.07,140.66 GPU1.R27 ; v2(167.24,140.11) 166.38,140.11 VRAM4.B2
FBA_D60: length 31.2
  L3 w0.114: v2(163.22,139.35) 163.31,139.26 163.31,137.95 162.27,136.91 151.2,136.91 144.9,143.21 141.65,143.21 141.45,143 v2(140.82,143)
  BOTTOM w0.14: VRAM4.E2 v2(163.22,139.35) ; v2(140.82,143) 139.99,143 139.34,142.36 138.71,142.36 138.32,141.96 138.32,141.42 138.23,141.32
FBA_D61: length 32.7
  L3 w0.089: 164.35,138.98 164.38,139.01 164.38,139.94 164.4,139.96 164.4,140.51 164,140.91 v2(164,140.93)
  L3 w0.114: v2(139.88,142.07) 141.16,142.07 141.84,142.75 144.71,142.75 151.01,136.45 162.5,136.45 163.85,137.8 163.85,138.48 164.35,138.98
  BOTTOM w0.14: v2(139.88,142.07) 138.98,142.07 GPU1.V27 ; VRAM4.E4 164,140.93 v2(164,140.93)
FBA_D62: length 29.5
  L3 w0.089: v2(162.4,139.33) 162.49,139.24 162.49,138.21
  L3 w0.114: v2(139.13,142.85) 139.9,142.85 140.73,143.68 145.08,143.68 151.39,137.36 161.64,137.36 162.49,138.21
  BOTTOM w0.14: VRAM4.F2 v2(162.4,139.33) ; GPU1.W27 138.66,142.88 v2(139.13,142.85)
FBA_D63: length 33.2
  L3 w0.089: 161.55,137.97 161.67,138.1 161.67,139.5 162,139.82 162,140.42 162.4,140.82 v2(162.4,140.93)
  L3 w0.114: 161.55,137.97 161.42,137.85 151.56,137.85 145.21,144.2 v2(140.49,144.2)
  BOTTOM w0.14: GPU1.W25 137.69,141.32 138.04,141.67 138.04,142.12 137.76,142.39 137.76,142.73 138.3,143.26 138.91,143.26 139.85,144.2 v2(140.49,144.2) ; VRAM4.F4 v2(162.4,140.93)
FBA_DEBUG0: length 18.2
  TOP w0.089: v2(144.09,131.37) 144.15,131.32 144.15,129.58 144.94,128.78 144.94,127.02 146.11,125.85 146.11,125.84 146.34,125.61 146.35,125.61 146.56,125.4 146.56,119.94 148.57,117.93 v1(148.85,117.93) 149.3,117.48 R7803.1
  BOTTOM w0.089: GPU1.F22 142.94,132.01 143.46,132.01 v2(144.09,131.37)
FBA_DEBUG1: length 22.1
  TOP w0.089: v2(141.79,133.8) 141.99,133.6 141.99,133.02 142.5,132.51 142.5,131.24 143.39,130.35 143.39,129.21 144.08,128.51 144.48,128.51 144.64,128.36 144.64,126.95 146.18,125.4 146.18,119.56 148.72,117.02 v1(148.72,116.72) 148.95,116.49 149.58,116.49 R7804.1
  BOTTOM w0.089: GPU1.J22 141.76,133.77 141.79,133.8 v2(141.79,133.8)
FBA_DQM0: length 15.5
  L6 w0.089: 145.11,127.53 144.31,128.34 143.68,128.34 v2(143.52,128.49) ; 152.6,126.21 152.61,126.23 153.77,126.23 153.77,126.23 154.56,126.23 154.56,126.23 155.37,126.23 155.37,126.24 155.61,126.24 156,126.63 v2(156,126.63)
  L6 w0.114: 145.11,127.53 145.49,127.15 146.59,127.15 147.53,126.21 152.6,126.21
  BOTTOM w0.14: v2(156,126.63) 156,126.63 VRAM1.D2 ; GPU1.D19 142.99,129.02 v2(143.52,128.49)
FBA_DQM1: length 23.7
  TOP w0.14: VRAM2.P13 v2(156,117.83)
  L6 w0.089: v2(156,117.83) 155.6,117.43 155.6,116.61 155.37,116.38 ; v2(138.88,126.09) 138.88,125.51 139.82,124.57 140.26,124.57 141.86,122.97
  L6 w0.114: 155.37,116.38 153.47,116.38 151.94,117.91 147.25,117.91 142.47,122.68 142.15,122.68 141.86,122.97
  BOTTOM w0.14: GPU1.D14 138.89,126.11 v2(138.88,126.09)
FBA_DQM2: length 30.9
  L3 w0.114: v2(164.8,117.83) 164.67,117.7 164.67,116.52 164.54,116.4 153.65,116.4 151.78,118.26 150.32,118.26 142.87,125.71 142.18,125.71 141.19,126.7 v2(141.19,127.29)
  BOTTOM w0.14: VRAM1.P13 v2(164.8,117.83) ; GPU1.C17 v2(141.19,127.29)
FBA_DQM3: length 23.9
  TOP w0.14: VRAM2.D2 164.39,127.03 v2(163.99,126.62)
  L3 w0.089: v2(163.99,126.62) 164.38,127.02 164.38,127.81 164.06,128.13 164.06,129.09
  L3 w0.114: 164.06,129.09 163.44,129.72 150.75,129.72 149.91,128.88 147.15,128.88 v2(146.38,129.65)
  BOTTOM w0.14: v2(146.38,129.65) 146.24,129.79 145.68,129.79 145.26,130.21 GPU1.C22
FBA_DQM4: length 19.1
  TOP w0.14: VRAM3.D2 v2(156,139.33)
  L6 w0.089: 154.9,137.7 155.14,137.94 155.14,138.48 155.43,138.77 155.44,138.77 v2(156,139.33) ; v2(139.99,137.86) 140.1,137.97 140.73,137.97 141.67,138.91
  L6 w0.114: 154.9,137.7 153.62,137.7 152.9,138.42 152.9,138.47 152.78,138.59 144.67,138.59 144.35,138.91 141.67,138.91
  BOTTOM w0.14: GPU1.P24 139.98,137.84 v2(139.99,137.86)
FBA_DQM5: length 25.9
  L6 w0.089: v2(156.02,148.91) 155.64,148.53 155.36,148.53 155.36,148.53 155.03,148.53 155.03,148.53 153.11,148.53 153.09,148.54
  L6 w0.114: v2(136.52,141.34) 136.66,141.48 136.66,142.14 140.66,146.15 146.69,146.15 147.62,147.09 147.79,147.09 148.02,146.86 148.18,146.86 148.34,147.02 148.34,147.18 148.11,147.41 148.11,147.57 148.27,147.74 148.43,147.74 148.66,147.5 148.83,147.5 148.99,147.66 148.99,147.83 148.76,148.06 148.76,148.22 149.08,148.54 153.09,148.54
  BOTTOM w0.14: VRAM4.P13 v2(156.02,148.91) ; v2(136.52,141.34) 136.52,141.32 136.53,141.31 GPU1.W24
FBA_DQM6: length 36.5
  TOP w0.14: VRAM3.P13 164.78,148.91 v2(164.78,148.95)
  L3 w0.114: v2(164.78,148.95) 164.57,149.16 164.57,149.76 164.16,150.17 161.04,150.17 160.79,150.42 150.6,150.42 149.82,151.2 144.67,151.2 141.07,147.6 138.86,147.6 136.92,145.66 136.92,145 v2(137.66,144.26)
  BOTTOM w0.14: v2(137.66,144.26) 137.66,143.66 136.52,142.51 GPU1.AA25
FBA_DQM7: length 33.5
  L3 w0.089: 164.86,138.09 164.86,139.27 v2(164.8,139.33)
  L3 w0.114: 164.86,138.09 164.86,137.71 162.66,135.51 151.3,135.51 144.52,142.29 142.09,142.29 v2(141.87,142.07)
  BOTTOM w0.14: v2(141.87,142.07) 140.72,142.07 140.18,141.53 139.92,141.53 139.22,140.83 139.22,140.61 138.77,140.16 GPU1.U25 ; VRAM4.D2 v2(164.8,139.33)
FBA_EDC0: length 16.8
  L6 w0.089: v2(141.81,130.18) 142.36,130.18 142.82,130.64 143.1,130.64 143.49,130.25 144.9,130.25 146.12,129.03 147.24,129.03 147.45,128.82 148.58,128.82
  L6 w0.114: 148.58,128.82 149.07,128.82 149.17,128.92 154.78,128.92 155.12,128.59 155.12,127.51 v2(155.2,127.43)
  BOTTOM w0.14: v2(141.81,130.18) 141.81,129.6 GPU1.E19 ; VRAM1.C2 v2(155.2,127.43)
FBA_EDC1: length 19.7
  TOP w0.14: VRAM2.R13 v2(155.2,118.63)
  L6 w0.089: v2(140,126.14) 140.8,125.34
  L6 w0.114: 140.8,125.34 141.34,125.34 147.68,119 152.17,119 152.83,118.34 154.91,118.34 v2(155.2,118.63)
  BOTTOM w0.14: v2(140,126.14) 140.6,126.14 GPU1.C15
FBA_EDC2: length 31.5
  L3 w0.114: v2(142.68,125.1) 143.18,125.1 144.28,124 144.28,123.52 149.99,117.81 151.48,117.81 151.74,117.54 153.28,116 165.01,116 165.51,116.5 165.51,118.54 v2(165.6,118.63)
  BOTTOM w0.14: 141.73,126.14 141.73,125.59 142.23,125.1 v2(142.68,125.1) ; VRAM1.R13 v2(165.6,118.63)
FBA_EDC3: length 23.3
  TOP w0.14: v2(164.8,127.43) 165.2,127.03 VRAM2.C2
  L3 w0.114: v2(147.04,129.64) 147.59,129.1 149.47,129.1 150.55,130.17 163.63,130.17 164.88,128.92 164.88,127.51 v2(164.8,127.43)
  BOTTOM w0.14: GPU1.B22 145.39,129.49 145.93,129.49 146.19,129.23 146.63,129.23 v2(147.04,129.64)
FBA_EDC4: length 16.8
  TOP w0.14: VRAM3.C2 v2(155.2,140.13)
  L6 w0.089: v2(155.2,140.13) 154.8,139.73 153.77,139.73 152.87,139.73 152.85,139.75
  L6 w0.114: 152.85,139.75 140.75,139.75 v2(139.99,138.99)
  BOTTOM w0.14: GPU1.R25 139.43,138.99 v2(139.99,138.99)
FBA_EDC5: length 32.3
  L6 w0.089: 153.36,147.71 154.78,147.71 v2(155.2,148.13) ; v2(136.53,140.2) 136.73,140.4 136.73,140.89 137.54,141.7 137.54,141.94
  L6 w0.114: 153.36,147.71 153.22,147.71 152.91,147.4 152.78,147.4 152.66,147.51 152.66,147.97 152.55,148.08 152.32,148.08 152.21,147.97 152.21,147.51 152.09,147.4 151.86,147.4 151.75,147.51 151.75,147.97 151.64,148.08 151.41,148.08 151.29,147.97 151.29,147.51 151.18,147.4 150.95,147.4 150.84,147.51 150.84,147.97 150.72,148.08 150.49,148.08 150.38,147.97 150.38,147.51 150.26,147.4 149.38,147.4 148.07,146.08 147.91,146.08 147.67,146.32 147.51,146.32 147.35,146.15 147.35,145.99 147.58,145.76 147.58,145.6 147.25,145.26 147.01,145.26 146.89,145.38 146.89,145.58 146.78,145.7 146.55,145.7 146.43,145.58 146.43,145.38 146.32,145.26 146.09,145.26 145.98,145.38 145.98,145.58 145.86,145.7 145.63,145.7 145.52,145.58 145.52,145.38 145.41,145.26 145.18,145.26 145.06,145.38 145.06,145.58 144.95,145.7 144.72,145.7 144.61,145.58 144.61,145.38 144.49,145.26 144.26,145.26 144.15,145.38 144.15,145.58 144.03,145.7 143.81,145.7 143.69,145.58 143.69,145.38 143.58,145.26 143.35,145.26 143.23,145.38 143.23,145.58 143.12,145.7 142.89,145.7 142.78,145.58 142.78,145.38 142.66,145.26 142.43,145.26 142.32,145.38 142.32,145.58 142.2,145.7 141.98,145.7 141.86,145.58 141.86,145.38 141.75,145.26 141.52,145.26 141.4,145.38 141.4,145.58 141.29,145.7 141.06,145.7 140.95,145.58 140.95,145.38 140.83,145.26 140.08,145.26 137.54,142.73 137.54,141.94
  BOTTOM w0.14: v2(136.53,140.2) 135.97,140.2 GPU1.W23 ; VRAM4.R13 v2(155.2,148.13)
FBA_EDC6: length 37.2
  TOP w0.14: VRAM3.R13 v2(165.6,148.13)
  L3 w0.089: 165.18,149.2 165.18,148.55 v2(165.6,148.13)
  L3 w0.114: 165.18,149.2 164.95,149.43 164.95,149.96 164.46,150.45 161.39,150.45 160.96,150.88 150.85,150.88 150.18,151.55 150.16,151.55 150.02,151.69 144.35,151.69 140.85,148.19 138.76,148.19 137.32,146.75 v2(136.72,146.75)
  BOTTOM w0.14: v2(136.72,146.75) 136.72,146 136.46,145.74 136.46,145.24 135.74,144.51 135.74,143.81 GPU1.AB26
FBA_EDC7: length 33.7
  L3 w0.089: v2(165.6,139.33) 165.71,139.22 165.71,138.05
  L3 w0.114: v2(140.95,141.18) 141.55,141.18 141.63,141.18 142.5,142.04 143.23,142.04 143.46,141.81 144.36,141.81 151.11,135.06 163.24,135.06 165.71,137.53 165.71,138.05
  BOTTOM w0.14: GPU1.T26 139.56,140.28 139.56,140.82 139.91,141.18 v2(140.95,141.18) ; VRAM4.C2 v2(165.6,139.33)
FBA_MF1: length 2.8
  TOP w0.089: R8111.2 160.3,129.54 160,129.54 v1(159.69,129.24) 159.69,128.96 160.22,128.43 v2(160.22,128.34)
  BOTTOM w0.089: v2(160.22,128.34) 160.22,128.33 160.4,128.15 VRAM1.J1
FBA_MF2: length 6.3
  TOP w0.089: v1(162.28,129.31) 162.28,130.07 R8112.1 161.72,130.18 161.37,129.82 159.74,129.82 159.31,129.39 159.31,129.01 159.82,128.5 159.82,128.17 160.16,127.83 VRAM2.J1
FBA_MF3: length 1.8
  TOP w0.089: VRAM3.J1 160.62,138.93 160.84,138.71 160.84,137.62 R8211.2
FBA_MF4: length 2.9
  TOP w0.089: v2(160.4,138.4) 160.12,138.12 v1(160.12,137.62) 161.03,136.7 R8210.1
  BOTTOM w0.089: VRAM4.J1 v2(160.4,138.4)
FBA_SEN0: length 9.3
  TOP w0.254: VRAM2.J10 v2(160.4,121.16)
  L6 w0.254: v2(160.4,121.16) 160.01,120.78 154.58,120.78 v2(154.05,121.3)
  BOTTOM w0.254: R8110.2 153.09,120.7 153.69,121.3 v2(154.05,121.3) ; VRAM2.J10 v2(160.4,121.16)
FBA_SEN2: length 10.7
  TOP w0.254: VRAM3.J10 160.4,145.92 160.4,145.45 v2(160.46,145.38)
  BOTTOM w0.254: VRAM3.J10 160.46,146.07 v2(160.46,145.38) 160.21,145.14 153.62,145.14 153.29,145.47 152.61,145.47 152.23,145.85 R8209.2
FBA_VREF_FET_H: length 1.1
  TOP w0.508: Q8201.D 164.54,134.29 R8202.2
FBA_VREF_FET_L: length 3.6
  BOTTOM w0.508: R8104.2 162.11,113.95 Q8101.D 162.85,113.34 163.16,113.03 164.57,113.03 v1(164.6,113.06)
FBA_VREFC0: length 8.9
  TOP w0.305: v2(160,117.03) VRAM2.J14
  TOP w0.508: R8107.1 159.95,115.85 C8103.1 159.97,117 v2(160,117.03)
  BOTTOM w0.305: VRAM2.J14 v2(160,117.03)
  BOTTOM w0.508: v2(160,117.03) 160,116.74 159.57,116.31 R8106.2 159.57,115.37 159.9,115.04 R8104.1 162.74,115.04 v1(163.22,114.56)
FBA_VREFC1: length 34
  TOP w0.305: VRAM3.J14 v2(160.78,149.71)
  TOP w0.508: v2(166.88,134.16) 166.75,134.29 R8202.1
  L5 w0.508: v2(166.88,134.16) 167.9,135.18 167.9,150.55 167.01,151.44 162.31,151.44 160.1,153.65 v2(160.1,153.8)
  BOTTOM w0.305: VRAM3.J14 v2(160.78,149.71)
  BOTTOM w0.508: v2(160.78,149.71) 160.81,149.74 R8203.2 160.73,150.88 C8202.1 160.73,152.3 v1(160.91,152.48) 160.91,152.99 v2(160.1,153.8) 160.05,153.75 R8204.1
FBA_WCK01: length 21.2
  TOP w0.14: VRAM2.P4 v2(156,125.03)
  L6 w0.102: v2(141.77,127.88) 141.89,127.76 142.94,127.76 144.2,126.5 144.75,126.5 147.62,123.62 153.39,123.62 153.65,123.37 153.65,122.41 153.77,122.29 154.06,122.29 154.2,122.43 154.2,123.29 154.47,123.56 155.75,123.56 156.05,123.86 156.05,124.87 155.99,125.02 v2(156,125.03)
  BOTTOM w0.114: v2(141.77,127.88) 141.77,128.43 GPU1.D18
  BOTTOM w0.14: VRAM2.P4 v2(156,125.03)
FBA_WCK01#: length 21.2
  TOP w0.14: VRAM2.P5 v2(156.8,125.03)
  L6 w0.102: v2(142.36,127.32) 142.6,127.56 142.86,127.56 144.12,126.3 144.66,126.3 147.54,123.42 153.31,123.42 153.45,123.28 153.45,122.33 153.69,122.09 154.14,122.09 154.4,122.34 154.4,123.21 154.55,123.36 155.83,123.36 156.25,123.78 156.25,124.5 156.79,125.03 v2(156.8,125.03)
  BOTTOM w0.114: v2(142.36,127.32) GPU1.C18
  BOTTOM w0.14: VRAM2.P5 v2(156.8,125.03)
FBA_WCK23: length 29
  TOP w0.14: VRAM2.D4 v2(164,125.03)
  L3 w0.102: v2(141.2,128.46) 141.15,128.58 141.15,128.78 141.28,128.9 141.46,128.9 141.56,128.8 141.83,128.8 142.09,129.06 142.63,129.06 142.98,128.71 142.98,128.42 143.9,127.5 145.16,127.15 146.25,127.15 147.49,126.6 151.94,125.37 153.2,124.1 153.92,123.87 154.65,123.63 163.08,123.63 164.48,124.19 164.6,124.31 164.6,124.53 164.54,124.59 163.93,124.59 163.86,124.66 163.86,124.89 v2(164,125.03)
  BOTTOM w0.114: GPU1.D17 v2(141.2,128.46)
  BOTTOM w0.14: v2(164,125.03) VRAM2.D4
FBA_WCK23#: length 29
  TOP w0.14: VRAM2.D5 v2(164.8,125.03)
  L3 w0.102: v2(140.6,127.86) 141.4,128.09 142.17,128.86 142.55,128.86 142.78,128.63 142.78,128.33 143.79,127.32 145.13,126.95 146.2,126.95 147.42,126.41 151.83,125.19 153.09,123.93 154.61,123.43 163.12,123.43 164.59,124.02 164.8,124.23 v2(164.8,125.03)
  BOTTOM w0.114: GPU1.D16 v2(140.6,127.86)
  BOTTOM w0.14: VRAM2.D5 v2(164.8,125.03)
FBA_WCK45: length 27.4
  TOP w0.14: v2(156.79,141.73) 156.4,141.33 VRAM3.D4
  L3 w0.102: v2(138.27,139.58) 138.56,139.58 138.68,139.71 138.68,140.95 138.19,141.44 138.19,143.4 139.8,145.01 141.71,145.01 141.86,144.86 145.82,144.86 147.91,142.77 153.39,142.77 153.77,143.16 155.96,143.16 156.2,142.91 156.2,142.32 v2(156.79,141.73)
  BOTTOM w0.14: GPU1.T24 138.28,139.57 v2(138.27,139.58) ; v2(156.79,141.73) 156.4,141.33 VRAM3.D4
FBA_WCK45#: length 27.5
  TOP w0.14: v2(156,141.73) VRAM3.D5
  L3 w0.102: v2(156,141.73) 156,142.83 155.87,142.95 153.85,142.95 153.47,142.57 147.82,142.57 145.74,144.65 141.77,144.65 141.62,144.81 139.88,144.81 138.39,143.32 138.39,141.53 138.89,141.03 138.89,139.63 138.68,139.42 138.46,139.2 v2(137.68,139.01)
  BOTTOM w0.14: GPU1.U24 137.69,139.01 v2(137.68,139.01) ; v2(156,141.73) VRAM3.D5
FBA_WCK67: length 30.1
  TOP w0.14: VRAM3.P4 164.39,141.33 v2(163.99,141.73)
  L6 w0.089: 140.29,141.61 140.26,141.59 139.05,140.38 138.77,140.26 138.69,140.24 137.71,140.24 v2(137.67,140.2)
  L6 w0.102: v2(163.99,141.73) 164.19,141.93 164.19,142.05 164.19,142.19 163.19,143.19 154.43,143.19 142.44,142.79 141.71,142.54 141.69,142.53 141.64,142.5 141.64,142.5 141.61,142.47 141.61,142.47 140.29,141.61
  BOTTOM w0.14: GPU1.V24 137.66,140.19 v2(137.67,140.2) ; VRAM3.P4 164.39,141.33 v2(163.99,141.73)
FBA_WCK67#: length 30
  TOP w0.14: VRAM3.P5 v2(164.8,141.73)
  L6 w0.089: 140.18,141.78 138.94,140.54 138.71,140.44 138.67,140.43 138.56,140.43 v2(138.25,140.74)
  L6 w0.102: v2(164.8,141.73) 164.39,142.14 164.39,142.27 163.28,143.39 154.43,143.39 142.41,142.99 141.63,142.73 141.59,142.71 141.46,142.63 141.46,142.62 141.45,142.61 140.18,141.78
  BOTTOM w0.14: v2(138.25,140.74) 138.23,140.76 GPU1.V25 ; VRAM3.P5 v2(164.8,141.73)
FBA_ZQ0: length 2.6
  BOTTOM w0.127: R8108.1 160.76,116.03 160.76,117.87 VRAM1.J13
FBA_ZQ1: length 3.5
  TOP w0.127: VRAM2.J13 160.78,117.85 160.78,116.3 R8113.1 160.61,115.19 v1(160.81,114.99)
FBA_ZQ2: length 2.4
  TOP w0.127: VRAM3.J13 160.05,148.88 160.05,150.78 R8212.1
FBA_ZQ3: length 3.3
  BOTTOM w0.127: VRAM4.J13 160.4,148.55 160.05,148.9 160.05,150.63 v1(159.95,150.72) 159.95,151.51 R8213.1
FFS_INT1: length 28.6
  L5 w0.089: v2(116.49,93.88) 114.98,92.37 114.45,92.37 114.37,92.29 114.04,92.29 113.95,92.37 112.54,92.37 111.83,93.07 111.54,93.07 111.53,93.08 109.16,93.08 109.15,93.07 108.82,93.07 108.64,92.89 v2(108.64,92.72)
  BOTTOM w0.089: v2(108.64,92.72) 108.64,92.89 109.01,93.26 CPU1.CG22 ; U7001.12 133.86,93.55 133.03,92.72 129.66,92.72 129.21,93.17 128.06,93.17 127.78,93.45 125.47,93.45 125.21,93.71 121.5,93.71 v1(121.29,93.5) 121.16,93.5 120.92,93.26 118.47,93.26 118.08,93.64 116.72,93.64 v2(116.49,93.88)
FFS_INT2: length 37.9
  TOP w0.089: Q7001.5 137.01,92.7 R2044.2 137.01,92.7 R7011.1 136.71,91.89 136.55,92.04 136.55,92.61 136.1,93.07 v1(135.03,93.07) v2(134.47,93.07)
  L5 w0.089: v2(120.7,92.83) 119.74,93.8 119.74,95.73 118.72,96.75 118.72,98.37 118.34,98.74 114.75,98.74 114.08,99.42 109.55,99.42 v2(109.15,99.01)
  BOTTOM w0.089: U7001.11 134.36,93.53 134.47,93.42 v2(134.47,93.07) 133.66,93.07 133.13,92.54 129.58,92.54 129.13,92.99 127.99,92.99 127.71,93.27 125.4,93.27 125.14,93.53 121.96,93.53 121.27,92.83 v2(120.7,92.83) ; v2(109.15,99.01) 109.66,99.52 CPU1.CH12
FFS_INT2_Q: length 113.9
  TOP w0.089: R7014.2 139.46,93.64 139.32,93.78 v1(138.89,93.78) v2(138.22,93.78) 138.14,93.7 Q7001.6 ; v2(171.11,62.93) 171.11,63.68 171.78,64.36 171.78,68.37 171.25,68.9 171.25,72.42 170.59,73.08 v2(170.59,73.43)
  L5 w0.089: v2(154.51,76.68) 154.28,76.91 137.62,76.91 137.34,77.2 137.34,77.92 137.06,78.2 137.05,78.2 136.05,79.21 136.05,88.04 138.22,90.21 v2(138.22,93.78)
  L6 w0.089: v2(155.37,38.25) 156.12,38.25 156.97,39.1 167.47,39.1 169.32,40.95 169.87,40.95 172.52,43.6 172.52,48.81 173.15,49.44 173.15,52.56 172.73,52.98 172.73,59.84 170.71,61.86 170.71,62.54 v2(171.11,62.93) ; v2(154.51,76.68) 154.97,77.14 157.01,77.14 157.13,77.01 161.78,77.01 163.44,75.35 163.55,75.25 164.28,75.25 165.05,74.48 165.05,73.91 165.05,73.77 165.79,73.03 170.18,73.03 v2(170.59,73.43)
  BOTTOM w0.089: HDD1.9 160.15,37.96 160.02,37.83 155.79,37.83 v2(155.37,38.25)
FLT_NXP3290: length 3.2
  TOP w0.089: R7414.2 v1(42.04,120.91) 42.19,121.06 42.57,121.06 42.85,121.33 42.85,121.56 43.15,121.86 U7403.A4
FP1_USB20_CON_N: length 19.9
  BOTTOM w0.114: R9209.1 205.96,56.15 206.31,56.15 ED9202.6 206.8,56.15 207.08,56.15 207.41,56.48 208.13,56.48 208.16,56.49 208.19,56.49 208.23,56.5 208.36,56.62 208.36,56.8 208.23,56.92 208.23,57.08 208.36,57.2 208.64,57.2 208.77,57.33 208.77,57.83 209.53,58.6 210.78,58.6 214.01,61.82 221.14,61.82 221.22,61.9 221.22,62.02 220.95,62.29 FP1.3
FP1_USB20_CON_P: length 19.9
  BOTTOM w0.114: FP1.4 221.45,61.81 221.24,61.6 214.1,61.6 210.87,58.37 209.63,58.37 208.99,57.74 ED9202.1 208.27,56.27 208.19,56.26 208.14,56.25 207.5,56.25 207.18,55.92 205.81,55.92 R9210.1
FP1_USB20_N: length 136.6
  TOP w0.114: v2(204.71,57.22) v1(205.11,56.82)
  L5 w0.102: v2(109.31,104.14) 109.58,103.88 109.69,103.88 110.56,104.75 111.77,104.75 113.23,103.28 116.7,103.28 116.91,103.49 119.1,103.49 120.32,102.27 120.32,99.65 121.06,98.91 121.06,98.2 121.49,97.77 121.49,95.91 124.59,92.81 124.59,73.32 131.33,66.57 159.5,66.57 159.68,66.4 170.47,66.4 172.12,64.75 173.16,64.75 173.66,64.75 174.4,64.01 174.4,61.29 175.92,59.77 178.8,59.77 181.7,56.87 190.55,56.87 191.34,57.66 193.26,57.66 194.1,58.5 204.1,58.5 204.47,58.12 204.47,57.46 v2(204.71,57.22)
  BOTTOM w0.114: v2(204.71,57.22) 204.68,57.22 204.24,56.78 204.24,56.26 204.33,56.17 204.49,56.17 204.75,56.44 R9209.2 ; CPU1.CG5 v2(109.31,104.14)
FP1_USB20_P: length 136.5
  TOP w0.114: v1(204.05,57.79) v2(204.05,57.23)
  L5 w0.102: v2(204.05,57.23) 204.27,57.45 204.27,58.04 204.02,58.29 194.19,58.29 193.35,57.46 191.42,57.46 190.64,56.67 181.61,56.67 178.72,59.56 175.84,59.56 174.2,61.21 174.2,63.92 173.58,64.54 173.24,64.54 172.04,64.54 170.39,66.19 159.59,66.19 159.41,66.37 131.25,66.37 124.39,73.23 124.39,92.73 121.29,95.83 121.29,97.69 120.86,98.12 120.86,98.83 120.12,99.57 120.12,102.19 119.02,103.29 117,103.29 116.79,103.08 113.15,103.08 111.68,104.54 110.64,104.54 109.77,103.68 109.52,103.68 v2(109.32,103.47)
  BOTTOM w0.114: v2(204.05,57.23) 204.02,57.2 204.02,56.16 204.45,55.73 R9210.2 ; CPU1.CG6 108.79,103.34 108.92,103.47 109.31,103.47 v2(109.32,103.47)
FP_3D3V: length 93
  TOP w0.254: Q9201.D 164.85,71.76 165.76,71.76 166.09,72.09 v2(166.09,72.37) ; R9201.1 207.08,65.41 207.29,65.2 AFTP9201.1 214.48,65.2 214.63,65.05 v2(214.63,65.03) 214.63,64.82 215.17,64.29 218.78,64.29 218.9,64.4 219.74,64.4 219.86,64.29 v2(220.4,64.29)
  TOP w0.305: v2(220.4,64.29) 220.41,64.3 220.41,64.71 221.01,65.3 222.48,65.3 ; 222.48,65.3 C9201.1 C9202.1 ; 222.48,65.3 221.92,64.74 R9211.1
  L3 w0.254: v2(174.04,72.26) 174.04,71.07 177.19,67.92 178.52,67.92 179.93,66.51 179.93,63.39 183.92,59.4 197.54,59.4 198.55,58.38 205.4,58.38 v2(205.87,57.91) 207.34,56.44 v2(207.34,55.49)
  BOTTOM w0.254: v2(174.04,72.26) 174.04,71.68 173.8,71.43 167.03,71.43 v2(166.09,72.37) ; v2(207.34,55.49) 207.3,55.49 207.27,55.45 ED9202.5 ; v2(220.4,64.29) 220.32,64.29 219.95,63.92 FP1.1 ; v2(214.63,65.03) 208.92,65.03 207.24,63.35 207.24,62.71 207.54,62.41 207.54,62.41 207.7,62.25 207.7,59.24 206.38,57.91 v2(205.87,57.91)
FP_EN#: length 7.6
  TOP w0.089: Q9202.D v1(162.31,70.73) 162.79,70.73 Q9201.G 163.65,68.97 C9203.1 164.39,68.96 164.7,69.27 165.89,69.27 166.8,70.18 R9212.2
FPR_SCAN#: length 302.6
  TOP w0.089: v2(132.82,33.96) 132.82,39.33 AFTP9204.1 134.87,39.57 135.07,39.77 v2(135.07,41.32) ; U2401.42 28.76,57.67 28.3,57.22 28.3,56.11 v2(28.73,55.68) ; v2(221.46,64.03) 221.01,64.03 220.78,63.81 219.92,63.81 219.62,64.11 219.02,64.11 218.88,63.96 214.84,63.96 214,64.8 213.67,64.8 213.57,64.9 203.71,64.9 R9201.2
  L3 w0.089: v2(221.46,64.03) 221.46,40.23 221.46,40.08 220.12,38.74 219.57,38.74 218.38,37.54 216.81,37.54 216.42,37.16 216.41,37.16 216.26,37.01 216.16,36.91 216.16,36.9 215.86,36.59 212.6,36.59 212.09,37.1 209.87,37.1 205.08,32.31 199.37,32.31 198.33,31.27 189.84,31.27 189.11,32 176.41,32 175.35,32 173.14,34.21 168.49,34.21 168.28,34.41 166.47,34.41 166.35,34.54 151.1,34.54 149.91,33.35 145.64,33.35 144.18,31.88 134.5,31.88 132.82,33.56 v2(132.82,33.96)
  L6 w0.089: v2(28.73,55.68) 28.09,56.32 25.89,56.32 25.73,56.17 25.46,56.17 24.6,55.3 24.28,55.3 22.92,53.94 22.92,50.93 22.05,50.06 22.05,43.44 22.6,42.89 22.6,38.34 25.1,35.84 30.84,35.84 31.75,36.75 33.2,36.75 34.25,37.8 34.25,42.57 35.58,43.91 60.15,43.91 61.14,42.92 83.59,42.92 85.66,40.84 89.82,40.84 90.02,41.05 90.68,41.05 90.71,41.08 94.03,41.08 94.26,40.85 103.45,40.85 103.92,41.33 105.29,41.33 107.66,43.7 109.64,43.7 111.11,45.18 126.38,45.18 129.14,42.42 134.52,42.42 135.07,41.87 v2(135.07,41.32)
  BOTTOM w0.089: FP1.7 222.95,63.36 222.28,64.03 v2(221.46,64.03)
GC6_FB_EN_GPU: length 11.1
  TOP w0.089: v2(132.24,105.87) 132.24,105.84 v1(131.63,105.23) 131.33,104.97 131.17,104.8 131.17,100.79 R7927.1 132.32,100.26 v2(132.39,100.33)
  BOTTOM w0.089: R7916.2 133.51,106.5 R7959.2 132.26,105.84 v2(132.24,105.87) ; Q7907.2 130.77,101.72 R7975.1 132.16,100.33 v2(132.39,100.33)
GC6_FB_EN_GPU_L: length 4.5
  BOTTOM w0.089: Q7907.6 132.13,103.66 R7952.1 ; Q7907.5 130.77,104.25 130.97,104.45 131.94,104.45 R7952.1 ; R7952.1 v1(133.32,103.96)
GC6_FB_EN_GPU_R: length 11.6
  BOTTOM w0.089: R7916.1 133.51,108.74 132.9,109.35 v1(132.9,110.39) 132.9,111.15 134.14,112.4 134.14,114.79 133.54,115.39 133.54,117.94 133.57,117.98
GC6_FB_EN_MCP: length 127.1
  TOP w0.089: v2(106.01,148.18) 106.01,148.12 105.95,148.06 U8803.2 ; v2(129.52,103.73) 129.52,102.97 128.53,101.98 128.53,98.2 128.2,97.87 128.2,93.75 127.82,93.37 127.82,89.83 127.99,89.66 128.4,89.66 128.65,89.41 128.65,87.02 127.49,85.85 v1(127.49,84.38) v2(127.49,81.61) ; v2(120.13,138.52) 118.93,137.31 111.56,137.31 109.63,135.38 109.63,132.21 116.28,125.56 117.9,125.56 119.84,123.62 v2(119.84,122.89)
  L3 w0.089: v2(108.13,89.16) 108.55,88.73 108.55,86.5 109.29,85.76 114.55,85.76 119.28,81.03 v2(122.95,81.03)
  L5 w0.089: v2(129.52,103.73) 128.89,103.73 127.02,105.6 127.02,109.8 127.64,110.42 127.64,114.92 123.51,119.05 123.51,119.78 121.54,121.75 120.18,121.75 119.84,122.08 v2(119.84,122.89)
  L6 w0.089: v2(106.01,148.18) 108.97,145.22 108.97,143.56 109.14,143.39 110.97,143.39 112.81,141.55 113.59,141.55 113.73,141.55 117.1,141.55 v2(120.13,138.52)
  BOTTOM w0.089: R7975.2 130.12,101.5 Q7907.3 130.12,102.47 128.91,103.68 R7953.2 v2(129.52,103.73) ; v2(127.49,81.61) 123.54,81.61 v2(122.95,81.03) ; CPU1.CE28 107.84,89.45 v2(108.13,89.16)
GC6_THM_DIS: length 15.4
  TOP w0.089: v2(25.48,63.4) 25.19,63.69 U2401.23
  BOTTOM w0.089: v2(25.48,63.4) 25.23,63.65 24.44,63.65 24.34,63.75 22.27,63.75 21.93,63.41 21.93,62.9 v1(21.82,62.79) 20.89,61.86 20.89,59.56 21.87,58.58 21.87,57.74 22.07,57.54 22.93,57.54 23.02,57.63 23.37,57.63 23.48,57.52 24.37,57.52 R2490.2
GC6_THM_DIS#_EC: length 2.4
  BOTTOM w0.089: R2471.2 23.58,57.94 v1(23.65,57.86) 23.65,58.22 R2426.2
GC6_THM_DIS#_PCH: length 118.9
  TOP w0.089: v2(111.59,81.84) 107.99,78.25 107.99,73.18 103.02,68.21 59.78,68.21 58.25,69.75 v2(58.25,71.45)
  BOTTOM w0.089: R2490.1 24.74,59.23 25.05,59.54 v1(25.05,59.67) 26.52,59.67 27.8,58.39 27.8,55.71 28.48,55.02 30.47,55.02 32.03,56.59 32.03,64.92 32.9,65.79 32.9,66.9 34.99,68.99 38.33,68.99 39.9,70.56 45.63,70.56 46.81,69.38 53.45,69.38 55.53,71.45 v2(58.25,71.45) ; v2(111.59,81.84) 111.59,82.66 111.44,82.81 111.44,83.9 111.61,84.08 111.61,84.3 111.15,84.76 CPU1.CL35
GFX_CLK_CPU_N: length 57.8
  TOP w0.114: v2(112.1,130.38) 112.42,130.38 112.7,130.66 114.12,130.66 119.28,135.82 123.04,135.82 123.84,135.02 123.96,134.95 v2(124.19,134.95)
  BOTTOM w0.114: CPU1.AW2 92.25,106.18 92.25,107 91.37,107.87 91.37,111.22 93.09,112.95 93.09,116.13 95.04,118.07 96.67,118.07 97.01,118.41 97.01,120.24 98.22,121.46 106.78,121.46 109.26,123.94 110.95,123.94 111.96,123.94 112.32,124.3 112.32,125.48 113.06,126.21 113.06,127.67 111.46,129.27 111.46,129.72 112.1,130.36 v2(112.1,130.38) ; v2(124.19,134.95) 124.2,134.95 GPU1.AD8
GFX_CLK_CPU_P: length 57.8
  TOP w0.114: v2(112.55,129.93) 112.55,130.18 112.8,130.43 114.21,130.43 119.37,135.59 122.94,135.59 123.6,134.93 v2(123.62,134.33)
  BOTTOM w0.114: CPU1.AY3 92.47,105.52 92.47,105.53 92.47,107.09 91.6,107.97 91.6,111.13 93.32,112.85 93.32,116.04 95.13,117.84 96.76,117.84 97.23,118.31 97.23,120.15 98.32,121.23 106.88,121.23 109.36,123.71 111.04,123.71 112.06,123.71 112.55,124.21 112.55,125.38 113.29,126.12 113.29,127.76 111.69,129.36 111.69,129.62 111.89,129.82 112.09,129.82 112.18,129.74 112.42,129.74 112.55,129.86 v2(112.55,129.93) ; GPU1.AE8 123.63,134.34 v2(123.62,134.33)
GFX_PCIE_RX_N0: length 54.5
  L5 w0.102: v2(103.7,100.8) 103.7,100.8 104.09,101.24 104.09,101.54 104.28,101.73 104.28,103.29 104.27,103.31 104.27,105.75 104.72,106.21 104.72,108.25 104.17,108.8 104.17,114.12 106.54,116.49 108.79,116.49 108.92,116.36 110.69,116.36 110.79,116.26 115.37,116.26 116.3,117.19 116.3,125.29 115.85,125.73 115.85,129.77 118.47,132.39 118.47,134.59 119.63,135.75 119.63,139.24 120.54,140.15 v2(120.68,140.15)
  BOTTOM w0.114: v2(103.7,100.8) 103.71,100.81 103.8,100.81 CPU1.BW9 ; C7602.1 121.36,139.51 120.72,140.15 v2(120.68,140.15)
GFX_PCIE_RX_N1: length 56
  L5 w0.102: v2(122.32,141.67) 121.36,141.91 120.34,141.91 118.47,140.04 118.47,135.74 117.66,134.92 117.66,132.88 115.04,130.26 115.04,125.17 115.48,124.72 115.48,117.62 115.04,117.17 109.26,117.17 109.13,117.3 106.2,117.3 103.36,114.45 103.36,108.3 103.86,107.79 103.86,106.63 103.38,106.14 103.38,104.09 103.25,103.96 103.25,103.27 v2(103.67,102.85)
  BOTTOM w0.114: v2(122.32,141.67) 122.93,141.06 C7604.1 ; CPU1.BU6 103.57,102.85 v2(103.67,102.85)
GFX_PCIE_RX_N2: length 58.2
  L5 w0.102: v2(123.26,142.92) 122.86,142.94 121.91,142.94 121.48,142.52 120.02,142.52 117.83,140.34 117.83,136.3 117.83,135.97 117.05,135.18 117.05,133.13 114.4,130.49 114.4,124.89 114.87,124.42 114.87,117.91 114.75,117.78 109.51,117.78 109.38,117.91 105.95,117.91 102.75,114.71 102.75,104.23 102.34,103.83 102.34,103.31 102.84,102.8 v2(102.85,102.8)
  BOTTOM w0.114: v2(123.26,142.92) 123.66,142.53 C7606.1 ; v2(102.85,102.8) CPU1.BT7
GFX_PCIE_RX_N3: length 63.8
  L5 w0.102: v2(124.37,144.08) 124.1,144.35 122.42,144.35 121.2,143.13 119.74,143.13 117.22,140.62 117.22,136.22 116.21,135.2 116.21,133.15 113.8,130.74 113.8,124.58 114.26,124.11 114.26,118.7 114.07,118.5 109.94,118.5 109.93,118.52 105.46,118.52 102.14,115.19 102.14,105.34 101.32,104.53 101.32,102.27 101.32,102.26 101.32,101.53 101.63,101.22 102.25,101.22 102.7,100.77 v2(102.95,100.77)
  BOTTOM w0.089: v2(102.95,100.77) 102.95,100.89 CPU1.BU9
  BOTTOM w0.114: C7608.1 124.87,143.3 124.68,143.5 124.37,143.81 v2(124.37,144.08)
GFX_PCIE_RX_P0: length 55.4
  L5 w0.102: v2(121.13,140.6) 120.89,140.84 120.5,140.84 120.25,140.59 120.25,140.15 119.43,139.32 119.43,135.84 118.27,134.67 118.27,132.47 115.65,129.85 115.65,125.65 116.09,125.21 116.09,117.27 115.28,116.46 110.87,116.46 110.77,116.56 109,116.56 108.88,116.69 106.45,116.69 103.97,114.2 103.97,108.71 104.52,108.16 104.52,106.29 104.06,105.84 104.06,103.22 104.08,103.21 104.08,101.86 103.68,101.46 v2(103.68,101.46)
  BOTTOM w0.114: v2(121.13,140.6) 121.13,140.06 121.26,139.93 C7601.1 ; CPU1.BW8 103.8,101.46 103.68,101.46 v2(103.68,101.46)
GFX_PCIE_RX_P1: length 55.6
  L5 w0.102: v2(121.87,141.22) 121.66,141.02 121.48,141.02 121.33,141.16 121.33,141.35 121.41,141.42 121.41,141.58 121.28,141.7 120.42,141.7 118.67,139.96 118.67,135.65 117.86,134.84 117.86,132.79 115.24,130.18 115.24,125.25 115.69,124.81 115.69,117.53 115.33,117.18 115.12,116.97 109.17,116.97 109.04,117.1 106.28,117.1 103.56,114.37 103.56,108.38 104.07,107.88 104.07,106.55 103.58,106.06 103.58,104.01 103.45,103.88 103.45,103.61 103.58,103.48 v2(103.66,103.48)
  BOTTOM w0.114: CPU1.BU5 103.56,103.48 v2(103.66,103.48) ; C7603.1 122.58,140.6 122.58,141.08 122.44,141.22 v2(121.87,141.22)
GFX_PCIE_RX_P2: length 57.8
  L5 w0.102: v2(122.81,142.47) 122.81,142.61 122.69,142.74 121.99,142.74 121.57,142.32 120.1,142.32 118.04,140.25 118.04,136.39 118.04,136.39 118.04,136.05 118.04,135.88 117.25,135.09 117.25,133.05 114.61,130.4 114.61,124.97 115.08,124.5 115.08,117.82 114.83,117.58 109.42,117.58 109.3,117.7 106.03,117.7 102.95,114.62 102.95,104.15 102.54,103.74 102.54,103.39 102.59,103.34 102.74,103.34 v2(102.84,103.44)
  BOTTOM w0.114: CPU1.BT6 102.33,103.31 102.56,103.54 102.74,103.54 v2(102.84,103.44) ; C7605.1 123.7,141.72 123.7,142.16 123.39,142.47 v2(122.81,142.47)
GFX_PCIE_RX_P3: length 63.8
  L5 w0.102: v2(102.8,101.43) 102.62,101.26 102.5,101.26 102.34,101.42 101.71,101.42 101.52,101.61 101.52,102.35 101.52,102.35 101.52,104.44 102.34,105.26 102.34,115.11 105.55,118.31 109.85,118.31 109.86,118.3 114.16,118.3 114.47,118.61 114.47,124.19 114,124.66 114,130.66 116.41,133.07 116.41,135.12 117.43,136.13 117.43,140.53 119.82,142.93 121.29,142.93 122.5,144.14 123.35,144.14 123.42,144.07 123.42,143.67 123.42,143.66 123.42,143.46 123.52,143.36 123.77,143.36 123.92,143.51 v2(123.92,143.63)
  BOTTOM w0.089: CPU1.BU8 103.25,101.58 103.12,101.45 102.81,101.45 v2(102.8,101.43)
  BOTTOM w0.114: v2(123.92,143.63) 124.21,143.63 124.54,143.31 124.54,143.13 124.39,142.98 124.39,142.82 124.51,142.71 124.69,142.71 C7607.1
GFX_PCIE_TX_C_N0: length 22.1
  BOTTOM w0.076: 103.8,108.33 103.8,108.31 103.82,108.28 103.82,106.97 103.71,106.86 103.71,106.85 103.67,106.81 103.67,106.35 103.68,106.32 103.7,106.27 103.7,106.05 103.67,105.97 103.67,105.67 103.68,105.66 103.82,105.34 103.82,104.81 CPU1.BW4
  BOTTOM w0.114: C1606.2 114.38,118.34 111.41,115.36 105.21,115.36 104.02,114.17 104.02,113.18 103.8,112.96 103.8,108.33
GFX_PCIE_TX_C_N1: length 24.2
  BOTTOM w0.076: CPU1.BU4 103.07,105.08 103.07,105.34 103.2,105.66 103.22,105.67 103.22,105.97 103.19,106.05 103.19,106.27 103.21,106.32 103.22,106.35 103.22,106.74 103.03,106.93 103.03,107.41 103.52,107.9 103.52,108.86 103.55,108.88 103.55,108.9
  BOTTOM w0.114: C1608.2 114.77,119.47 111.21,115.91 104.89,115.91 103.55,114.57 103.55,108.9
GFX_PCIE_TX_C_N2: length 16.6
  BOTTOM w0.076: CPU1.BU2 102.5,106.35 102.5,107.62 102.9,108.02 102.9,109.35 102.87,109.38 102.87,109.39
  BOTTOM w0.114: 102.87,109.39 102.87,113.59 102.64,113.82 102.64,115.13 104.73,117.22 108.49,117.22 C1603.2
GFX_PCIE_TX_C_N3: length 16.9
  BOTTOM w0.076: CPU1.BT4 102.22,104.87 101.97,105.12 101.97,105.69 102.15,105.88 102.15,107.88 102.44,108.17 102.44,108.39 102.42,108.42 102.42,108.44
  BOTTOM w0.114: 102.42,108.44 102.42,113.04 101.88,113.57 101.88,115.59 104.61,118.31 106.12,118.31 C1612.2
GFX_PCIE_TX_C_P0: length 22.1
  BOTTOM w0.076: 104.03,108.33 104.03,108.31 104,108.28 104,106.9 103.89,106.79 103.89,106.77 103.85,106.73 103.85,106.38 103.88,106.3 103.88,106.02 103.85,105.94 103.85,105.73 104,105.38 104,105.28 CPU1.BW3
  BOTTOM w0.114: C1605.2 115.08,117.69 115.08,117.5 114.96,117.38 114.76,117.38 114.35,117.78 114.15,117.78 112.94,116.57 111.5,115.13 105.31,115.13 104.24,114.07 104.24,113.08 104.03,112.86 104.03,108.33
GFX_PCIE_TX_C_P1: length 24.5
  BOTTOM w0.076: CPU1.BU3 102.89,105.28 102.89,105.38 103.04,105.73 103.04,105.94 103.01,106.02 103.01,106.3 103.04,106.38 103.04,106.67 102.85,106.86 102.85,107.49 103.34,107.98 103.34,108.86 103.32,108.88 103.32,108.9
  BOTTOM w0.114: 103.32,108.9 103.32,114.66 104.79,116.14 111.12,116.14 114.55,119.57 114.55,119.75 114.2,120.09 114.2,120.3 114.36,120.46 114.54,120.46 C1607.2
GFX_PCIE_TX_C_P2: length 15.6
  BOTTOM w0.076: CPU1.BU1 102.71,106.56 102.67,106.6 102.67,107.54 103.08,107.95 103.08,109.35 103.1,109.38 103.1,109.39
  BOTTOM w0.114: C1604.2 108.34,116.99 104.83,116.99 102.87,115.04 102.87,113.91 103.1,113.68 103.1,109.39
GFX_PCIE_TX_C_P3: length 16.8
  BOTTOM w0.076: 102.64,108.44 102.64,108.42 102.62,108.39 102.62,108.1 102.33,107.81 102.33,105.88 102.53,105.68 102.53,105.19 102.47,105.13 102.35,105.13 102.22,105.26 CPU1.BT3
  BOTTOM w0.114: C1611.2 105.96,118.09 104.7,118.09 102.11,115.5 102.11,113.67 102.64,113.13 102.64,108.44
GFX_PCIE_TX_N0: length 21.3
  BOTTOM w0.114: C1606.1 115.18,118.98 116.64,120.45 116.64,125.28 115.95,125.97 115.95,129.31 118.27,131.62 118.27,134.06 119.79,135.59 121.41,135.59 121.55,135.44 GPU1.AG7
GFX_PCIE_TX_N1: length 22.4
  BOTTOM w0.114: 123.04,134.31 122.4,134.47 122.12,134.71 122.12,135.07 122.26,135.2 122.26,135.59 121.79,136.06 119.55,136.06 117.8,134.3 117.8,131.81 115.48,129.5 115.48,125.74 116.03,125.19 116.03,120.98 115.8,120.75 C1608.1
GFX_PCIE_TX_N2: length 30.1
  BOTTOM w0.114: C1603.1 110.56,117.41 111.53,118.39 111.53,119.7 112,120.17 113.03,120.17 115.1,122.24 115.1,124.3 114.56,124.84 114.56,129.88 116.84,132.17 116.84,134.77 119.06,136.98 120.25,136.98 122.08,136.98 122.9,136.16 123.26,136.16 123.35,136.06 GPU1.AF9
GFX_PCIE_TX_N3: length 32.8
  BOTTOM w0.114: GPU1.AG10 123.28,137.19 123.06,137.41 122.65,137.41 122.39,137.68 120.54,137.68 118.69,137.68 116.11,135.1 116.11,132.42 113.86,130.17 113.86,124.55 114.4,124 114.4,122.63 113.54,121.77 111.41,121.77 110.77,121.13 110.77,118.92 110.19,118.34 107.38,118.34 C1612.1
GFX_PCIE_TX_P0: length 21.3
  BOTTOM w0.114: 115.63,118.43 115.63,118.45 115.55,118.53 115.55,119.03 116.87,120.35 116.87,125.38 116.18,126.06 116.18,129.21 118.49,131.52 118.49,133.97 119.88,135.36 121.31,135.36 121.46,135.21 121.46,135 GPU1.AG6
GFX_PCIE_TX_P1: length 22.1
  BOTTOM w0.114: GPU1.AF7 122.69,135.09 122.69,135.48 121.88,136.28 119.45,136.28 117.57,134.4 117.57,131.91 115.26,129.6 115.26,125.64 115.8,125.1 115.8,121.08 115.66,120.93 115.36,120.93 C1607.1
GFX_PCIE_TX_P2: length 31
  BOTTOM w0.114: 124.23,135.5 123.31,135.8 123.28,135.83 123.26,135.83 123.16,135.93 122.95,135.93 122.81,135.93 121.98,136.75 120.16,136.75 120.16,136.76 119.15,136.76 117.07,134.67 117.07,132.08 114.79,129.79 114.79,124.94 115.33,124.39 115.33,122.14 113.13,119.94 112.09,119.94 111.76,119.61 111.76,118.3 110.65,117.18 110.02,117.18 109.6,116.76 C1604.1
GFX_PCIE_TX_P3: length 32.8
  BOTTOM w0.114: C1611.1 107.6,118.11 110.28,118.11 111,118.83 111,121.03 111.51,121.54 113.64,121.54 114.63,122.54 114.63,124.1 114.09,124.64 114.09,130.08 116.34,132.33 116.34,135 118.79,137.45 118.86,137.45 122.29,137.45 122.56,137.19 122.97,137.19 123.22,136.94 123.22,136.75 GPU1.AG9
GPCPLL_AVDD: length 8.6
  TOP w0.305: v2(137.08,125.54) 137.21,125.67 C8051.1 136.86,126.98 C8047.1
  TOP w0.508: v2(137.08,125.54) 137.24,125.38 137.24,125.12 137.39,124.97 137.4,124.97 138.29,124.07 v1(138.29,124.07) 138.29,122.85 C8048.1 138.05,121.26 R8003.2
  BOTTOM w0.305: GPU1.F11 136.56,125.54 v2(137.08,125.54)
GPD11/LANPHYPC: length 55.9
  TOP w0.089: R1721.2 145.23,69.94 v2(144.76,69.47) v1(145.07,68.98)
  BOTTOM w0.076: CPU1.BU34 103.17,85.74 103.56,85.35 103.56,84.75 103.59,84.65 103.59,84.36 103.57,84.3 103.57,84.06 103.59,84 103.59,83.76 103.76,83.59
  BOTTOM w0.089: 103.76,83.59 104.35,83 104.35,81.27 105.49,80.13 105.49,78.95 105.77,78.67 105.77,76.69 111.7,70.76 115.07,70.76 115.07,70.77 115.84,70.77 118.45,68.15 132.07,68.15 132.31,67.91 138.76,67.91 140.8,69.95 141.55,69.95 141.86,69.64 141.86,69.35 142.17,69.04 144.33,69.04 v2(144.76,69.47)
GPD_7: length 47.6
  TOP w0.089: R1524.2 v2(139.38,69.52) v1(139.91,69.17)
  BOTTOM w0.089: v2(139.38,69.52) 138.13,68.26 132.46,68.26 132.22,68.51 118.6,68.51 115.98,71.12 114.92,71.12 114.92,71.12 111.99,71.12 111.85,71.12 106.12,76.84 106.12,78.82 105.85,79.1 105.85,80.28 104.71,81.42 104.71,83.2 104.17,83.74 104.17,84.46 103.83,84.8 CPU1.BV35
GPIO5_FRAME_LOCK#: length 6.2
  BOTTOM w0.089: R7963.1 135.77,112.88 135.77,113.89 v1(135.36,114.3) 135.36,115.67 134.71,116.33 GPU1.A3
GPIO6_VGA_CORE_PSI: length 11.9
  BOTTOM w0.114: R7966.1 R7965.1 136.41,109.44 v1(137.48,109.44) 137.48,114.57 135.51,116.54 135.51,118.3 GPU1.A4
GPIO9_ALERT: length 19.8
  L5 w0.089: v2(136.66,116.77) 133.58,119.84 133.58,122.71 133.99,123.12 v2(134.78,123.12)
  BOTTOM w0.089: GPU1.F8 v2(134.78,123.12) ; RN7910.2 v1(137.6,108) 138.19,108.59 138.19,115.23 v2(136.66,116.77)
GPIO10_FBVREF: length 65.4
  TOP w0.089: Q8201.G 163.26,132.58 163.58,132.89 166.37,132.89 v2(166.75,133.28)
  L5 w0.089: v2(135.31,120.27) 135.94,120.27 138.64,117.58 143.11,117.58 145.95,114.73 148.97,114.73 149.17,114.54 150.06,114.54 150.63,113.97 152.78,113.97 153.78,112.97 160.93,112.97 v2(161.09,113.13) 162.18,114.23 167.26,114.23 168.2,115.16 168.2,121.72 167.86,122.07 167.86,122.42 168.15,122.72 168.15,131.88 v2(166.75,133.28)
  BOTTOM w0.089: v2(161.09,113.13) 160.34,112.39 Q8101.G 158.8,113.55 R7910.1 157.91,114.45 v1(157.71,114.45) ; GPU1.C5 v2(135.31,120.27)
GPIO11_LCD_VDD: length 22.1
  L6 w0.089: v2(134.78,121.99) 134.78,121.42 135.77,120.43 135.77,120.37 136.26,119.88 136.26,119.54 135.77,119.05 135.77,116.9 136.73,115.93 136.73,107.41 136.15,106.83 136.15,105.32 v2(136.65,104.81)
  BOTTOM w0.089: R7961.1 135.72,105.67 135.72,105.04 v1(135.94,104.81) v2(136.65,104.81) ; GPU1.E7 v2(134.78,121.99)
GPIO13_LCD_BLEN: length 5.8
  BOTTOM w0.089: GPU1.B4 134.71,118.5 135.09,118.11 135.09,116.48 136.25,115.32 136.25,115.12 ; v1(136.26,115.12) 136.25,115.12 ; 136.25,115.12 R7913.1
GPP_E23_STRAP: length 3.8
  TOP w0.089: v2(114.76,105.06) 114.38,104.67 TP402.1
  BOTTOM w0.089: CPU1.CN4 112.54,104.85 113.01,104.85 113.42,104.44 114.14,104.44 v2(114.76,105.06)
GPP_H1_SFRM: length 126
  TOP w0.114: v2(110.79,87.16) 109.96,86.33 109.96,85.5 109.97,85.49 109.97,82.88 107.76,80.67 107.76,73.28 102.93,68.44 59.88,68.44 58.54,69.78 58.54,69.97 58.54,69.97 58.54,70.33 58.91,70.7 58.91,78.72 60.33,80.14 60.9,80.14 63.1,82.33 63.1,85.89 60.22,88.77 58.5,88.77 54.87,92.39 54.87,99.47 53.8,100.55 41.74,100.55 40.9,101.39 40.9,102.37 38.09,105.19 37.74,105.19 v1(37.14,105.79) 37.14,105.79 36.55,106.38 R1913.2
  BOTTOM w0.114: v2(110.79,87.16) 110.68,87.16 CPU1.CJ32
GPP_H2_CLKREQ0: length 128.4
  TOP w0.089: v2(109.93,89.13) 110.33,88.73 110.33,86.98 109.74,86.39 109.74,82.97 107.48,80.71 107.48,73.32 102.83,68.67 59.97,68.67 58.76,69.88 58.76,70.23 59.14,70.61 59.14,78.63 60.43,79.91 61,79.91 63.32,82.24 63.32,85.98 60.31,88.99 58.59,88.99 55.1,92.48 55.1,99.57 54.03,100.64 53.89,100.78 41.84,100.78 41.13,101.48 v1(41.13,102.67) 38.38,105.42 38.01,105.42 37.09,106.35 37.09,107.37 36.8,107.66 R1912.2
  BOTTOM w0.089: CPU1.CH29 109.89,89.13 v2(109.93,89.13)
GPP_H21: length 23.9
  TOP w0.089: v2(107.9,90.6) 107.67,90.83 v1(107.67,91.11)
  L3 w0.089: v2(107.9,90.6) 108.38,91.08 110.02,91.08 110.82,90.27 111.05,90.27 113.19,88.14 114.12,88.14 115.98,86.28 116.96,86.28 117.85,87.18 117.85,87.35 119.01,88.5 v2(119.8,88.5)
  BOTTOM w0.089: CPU1.CF25 108.36,90.85 108.1,90.6 v2(107.9,90.6) ; v2(119.8,88.5) 120.2,88.9 121.36,88.9 123.83,86.44 R1522.2
GPP_H23: length 16
  BOTTOM w0.089: CPU1.CM26 111.96,91.04 113.71,91.04 113.94,90.81 115.01,90.81 115.19,90.63 118.39,90.63 v1(118.54,90.48) 119.05,90.48 119.56,89.97 120.56,89.97 123.33,87.2 R1513.2
GPPC_H18_VCCIO_LPM: length 170.3
  TOP w0.089: v2(117.4,89.49) 117.78,89.49 119.3,87.97 121.64,87.97 123.14,86.46 123.14,82.68 117.67,77.21 117.67,72.74 115.83,70.89 115.83,69.15 106.81,60.14 101.62,60.14 101.3,59.82 54.58,59.82 53.93,59.82 44.35,50.24 44.29,50.24 43.69,49.64 43.69,48.2 43.27,47.78 v2(42.62,47.78) ; v2(88.7,41.58) 89.03,41.25 v1(89.03,41.1) 89.09,41.1 89.61,40.57 R4034.1
  L6 w0.089: v2(88.7,41.58) 87.18,43.1 61.21,43.1 59.74,44.56 59.74,45.72 58.93,46.53 58.93,49.14 57.98,50.09 44.14,50.09 42.62,48.57 v2(42.62,47.78)
  BOTTOM w0.089: v2(117.4,89.49) 114.1,89.49 113.77,89.82 112.89,89.82 CPU1.CN27
GPU_CLKREQ#: length 45
  TOP w0.089: v2(132.51,98.17) v1(132.51,98.72)
  L6 w0.089: v2(121.87,131.36) 120.91,130.39 120.91,127 129.53,118.37 129.76,118.37 130.9,117.23 130.9,116.73 132.97,114.66 132.97,111.31 132.04,110.39 132.04,108.83 133.3,107.58 133.3,106.62 133.02,106.34 133.02,102.26 132.83,102.07 132.83,98.48 v2(132.51,98.17)
  BOTTOM w0.089: v2(121.87,131.36) 121.87,131.37 122.81,132.31 122.9,132.31 122.9,132.31 123.3,132.31 GPU1.AC6 ; R7603.1 133.54,97.5 Q7601.S 133.11,97.5 132.51,98.1 v2(132.51,98.17)
GPU_EVENT_GPU#: length 8.9
  TOP w0.089: v2(134.91,108.81) 134.67,108.81 134.55,108.68 v1(134.55,107.47) 134.55,105.34 v2(135,104.88)
  BOTTOM w0.089: R7965.2 134.96,108.87 v2(134.91,108.81) ; v2(135,104.88) 134.9,104.88 134.34,104.32 133.53,104.32 R7964.2 132.73,105.05 Q7906.S
GPU_EVENT_GPU#_R: length 18.6
  L6 w0.089: v2(134.98,105.52) 134.98,105.94 136.29,107.26 136.29,116.09 134.75,117.63 v2(134.75,120.83)
  BOTTOM w0.089: v2(134.75,120.83) 134.78,120.86 GPU1.D6 ; R7964.1 134.39,105.08 v1(134.5,105.18) 134.83,105.52 v2(134.98,105.52)
GPU_EVENT_MCP#: length 49.1
  TOP w0.089: v2(128.22,87.28) 127.51,87.28 127.36,87.43 v1(127.36,90.2) 127.36,93.22 128.02,93.88 128.02,96.13 128.02,96.13 128.02,98.6 128.35,98.93 128.35,102.16 128.86,102.67 128.86,103.86 v2(129.51,104.52)
  L3 w0.089: v2(121.67,89.49) 121.38,89.49 119.96,88.06 118.82,88.06 118.03,87.27 118.03,87.1 117.03,86.1 115.91,86.1 114.33,87.68 113.3,87.68 111.01,89.97 110.85,89.97 109.92,90.9 108.8,90.9 108.08,90.18 107.54,90.18 v2(107.13,90.59)
  BOTTOM w0.089: v2(107.13,90.59) 107.13,90.5 CPU1.CC27 ; R7948.1 v2(129.51,104.52) 129.77,104.78 Q7906.D ; v2(121.67,89.49) 121.67,89.71 122.02,90.06 126.76,90.06 127.1,89.71 127.1,88.39 128.22,87.28 v2(128.22,87.28)
GPU_I2C:
  vias: v1(142.31,105.23)
GPU_I2CA_SCL: length 14.9
  BOTTOM w0.114: RN7701.1 138.43,107.59 138.71,107.87 v1(138.71,108.57) 138.71,110.45 138.53,110.63 138.53,116.9 136.82,118.6 136.82,120.03 136.47,120.38 GPU1.B7
GPU_I2CA_SDA: length 14.7
  BOTTOM w0.114: RN7701.2 139.1,107.29 v1(139.75,107.95) 139.75,109.88 138.78,110.86 138.78,117.03 137.04,118.77 137.04,120.31
GPU_PEX_RST#: length 47.3
  L6 w0.089: v2(132.33,101.85) 132.36,101.85 132.84,102.33 132.84,106.28 131.52,107.59 131.52,110.12 132.79,111.39 132.79,114.54 130.71,116.62 130.71,117.15 129.68,118.18 129.43,118.18 120.5,127.12 120.5,130.62 123.66,133.79 v2(124.15,133.79)
  BOTTOM w0.089: v2(132.33,101.85) 133.06,101.13 U7602.4 133.93,101.13 134.38,100.67 136.41,100.67 v1(136.5,100.76) 136.53,100.79 R7613.2 138.2,100.79 R7614.1 ; GPU1.AC7 124.17,133.72 124.15,133.74 v2(124.15,133.79)
GPU_PEX_RST_HOLD: length 8.1
  TOP w0.089: v2(135.77,107.85) 135.77,107.8 135.87,107.7 135.87,104.67 v2(136.61,103.93)
  BOTTOM w0.089: v2(135.77,107.85) 136.12,107.85 R7973.2 ; U7602.1 135.21,102.96 135.31,103.06 135.84,103.06 135.96,103.18 R7931.2 136.17,103.48 v2(136.61,103.93) 136.96,103.57 v1(136.96,103.48)
GPU_PEX_RST_HOLD_GPU#: length 15.3
  BOTTOM w0.089: GPU1.C4 134.62,119.67 136.06,118.22 136.06,116.49 137.83,114.72 137.83,109.23 137.57,108.97 137.24,108.97 R7973.1 136.99,108 136.23,107.25 v1(136.01,107.25)
GPU_PWR_LEVEL: length 300.2
  TOP w0.127: v2(151.79,111.51) v1(152.63,111.51) 152.83,111.51 154.18,110.16 154.18,107.49 155.01,106.66 155.01,102.69 157.83,99.88 157.83,99.87 157.85,99.84 157.85,98.52 159.64,96.73 v2(159.64,94.79) ; v2(169.4,62.46) 169.54,62.6 169.54,63.82 170.12,64.4 170.12,64.76 170.84,65.48 170.84,68.27 170.36,68.74 170.36,70.63 169.09,71.9 169.09,73.58 168.82,73.85 168.82,76.21 v2(168.97,76.35) ; U2401.10 23.06,68.89 22.85,68.68 21.77,68.68 21.54,68.45 v2(21.54,68.4)
  L5 w0.127: v2(159.64,94.79) 160.07,94.36 160.07,90.67 160.76,89.99 160.76,87.35 165.46,82.65 165.46,79.8 168.9,76.35 v2(168.97,76.35) ; v2(145.04,37.54) 145.04,37.54 145.57,38.08 150.83,38.08 151.92,39.17 153.85,39.17 v2(154.89,40.21) ; v2(86.46,31.62) 85.54,32.54 83.55,32.54 82.93,31.93 61.7,31.93 61.05,31.28 36.49,31.28 32.13,26.92 32.13,26.08 30.49,24.44 21.79,24.44 14.77,31.46 14.77,35.2 14.53,35.44 14.53,41.96 12.28,44.21 12.28,46.52 14.44,48.67 14.44,51.39 14.58,51.54 14.58,57.33 20.11,62.85 20.11,66.43 21.54,67.86 v2(21.54,68.4)
  L6 w0.127: v2(86.46,31.62) 88.19,33.35 103.01,33.35 103.64,33.99 103.64,35.37 105.64,37.37 105.64,37.7 108.49,40.55 108.9,40.55 112.29,43.94 124.59,43.94 128.47,40.07 129.77,40.07 130.46,39.38 143.2,39.38 v2(145.04,37.54) ; v2(154.89,40.21) 154.89,40.24 155.81,41.16 168.33,41.16 168.93,41.76 169.63,41.76 171.55,43.67 171.55,53.62 171.95,54.02 171.95,59.54 169.4,62.1 v2(169.4,62.46)
  BOTTOM w0.127: PQ4402.D 159.85,95 v2(159.64,94.79) ; D7902.K 150.86,111.51 v2(151.79,111.51)
GPU_ROM: length 16.7
  BOTTOM w0.089: v1(150.1,119.91) 150.12,119.92 150.12,120.83 149.63,121.31 R7935.1 149.26,121.32 R7918.1 ; v1(150.1,119.91) R7920.1 148.13,118.15 R7947.1 ; v1(150.1,119.91) 151.19,119.91 152.76,118.34 152.76,115.22 153.37,114.61 153.37,113.31 153.77,112.9 R7946.1
GPU_ROM_SCLK: length 12.7
  BOTTOM w0.114: R7921.1 148.06,119.74 R7920.2 v1(145.77,118.94) 143.93,118.94 143.32,119.55 143.32,119.55 142.95,119.91 142.52,119.91 139.42,123.02 139.42,123.28 139.4,123.29 139.4,123.33 139.07,123.67 139.07,124.13 138.85,124.35 GPU1.C12
GPU_ROM_SI: length 11.9
  BOTTOM w0.114: GPU1.B12 139.63,123.6 139.63,123.11 141.65,121.08 142.18,121.08 v1(142.89,120.37) 143.52,119.74 146.87,119.74 147.65,120.52 R7924.1 148.39,120.85 R7935.2
GPU_ROM_SO: length 11.5
  BOTTOM w0.114: GPU1.A12 139.98,123.12 141.61,121.49 v1(142.42,121.49) 143.83,120.08 146.35,120.08 148.36,122.09 R7918.2 R7932.1
GPU_THM_SMBCLK: length 381
  TOP w0.114: R2460.2 215.27,54.66 214.76,55.17 214.76,55.61 214.61,55.77 214.61,57.88 212.65,59.83 212.65,60.34 v1(211.38,61.62) 210.99,62.01 210.99,63.22 210.52,63.69 208.52,63.69 v2(207.75,62.92) 207.39,62.92 206.91,62.43 204.7,62.43 203.3,63.83 200.79,63.83 199.85,64.77 R2459.2 ; v2(21.91,66.48) 21.91,67.53 22.48,68.09 U2401.12 ; v2(35.06,102.9) 34.84,102.68 Q5801.3
  L3 w0.089: v2(207.75,62.92) 208.59,62.08 210.55,62.08 213.48,59.15 214.18,59.15 218.54,54.79 218.54,39.1 217.9,38.46 217.19,38.46 216.43,38.46 216.04,38.07 216.03,38.07 215.47,37.51 212.97,37.51 212.47,38.01 209.31,38.01 205.81,34.52 200.27,34.52 197.77,32.01 190.17,32.01 189.44,32.74 175.65,32.74 172.75,35.65 168.17,35.65 167.81,36.01 166.76,36.01 166.45,36.01 165.71,35.28 150.77,35.28 149.57,34.08 145.15,34.08 145.14,34.07 145.12,34.07 144.63,33.58 v2(141.23,33.58)
  L6 w0.114: v2(35.06,102.9) 34.27,102.11 34.27,100.81 37.62,97.46 37.62,95.23 37.63,95.23 37.63,95.17 37.88,94.92 41.33,94.92 43.28,92.97 43.28,86.23 44.54,84.98 44.54,84.8 44.54,82.03 43.11,80.59 43.11,75.77 42.39,75.05 41.6,75.05 40.94,74.39 40.94,73.27 38.33,70.66 35.99,70.66 34.27,72.38 29.85,72.38 28.39,70.92 26.04,70.92 21.91,66.79 v2(21.91,66.48) 21.87,66.44 21.87,64.62 23.04,63.45 23.04,61.57 22.18,60.71 21.49,60.71 19.53,58.75 19.53,40.25 20.85,38.93 20.85,35.97 21.12,35.7 21.12,27.57 23.03,25.67 37.05,25.67 41.26,29.88 89.04,29.88 90.64,31.48 104.26,31.48 107.33,34.56 108.24,34.56 110.81,37.12 110.81,41.01 112.66,42.86 123.97,42.86 128.13,38.7 128.97,38.7 129.58,38.09 138.09,38.09 140.11,36.07 141.76,36.07 142.27,35.56 142.27,34.9 141.23,33.86 v2(141.23,33.58)
