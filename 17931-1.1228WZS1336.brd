# Allegro board 17931-1.1228WZS1336.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_A12: length 54.8
  L5 w0.14: v2(78.05,77.73) 77.83,77.73 77.26,77.15 77.26,75.64 75.64,74.02 75.64,73.25 75.5,73.11 75.2,73.11 75.06,72.97 75.06,72.69 75.2,72.55 75.5,72.55 75.64,72.41 75.64,70.56 75.5,70.42 74.34,70.42 74.2,70.28 74.2,70.01 74.34,69.87 75.5,69.87 75.64,69.73 75.64,69.45 75.5,69.31 74.34,69.31 74.2,69.17 74.2,68.89 74.34,68.75 75.7,68.75 75.87,68.58 75.87,68.32 75.7,68.15 74.37,68.15 74.25,68.02 74.25,66.67 60.64,53.06 60.64,52.72 60.64,52.72 60.64,49.31 60.51,49.19 60.24,49.19 v2(59.97,49.46)
  BOTTOM w0.076: CPU1.AA34 80.52,85.8 80.21,85.15 80.21,84.21 80.18,84.17 80.17,84.15 80.1,84.04 80.1,83.62 80.3,83.42 80.3,83.07 79.53,82.3 79.53,81.84
  BOTTOM w0.14: DM1.119 59.83,49.6 v2(59.97,49.46) ; 79.53,81.84 79.53,80.62 78.96,80.05 78.96,78.09 78.59,77.73 v2(78.05,77.73)
M_A_A13: length 56.9
  L5 w0.14: v2(81.69,86.59) 81.69,85.67 82.73,84.62 82.99,84.62 83.93,83.68 85.12,83.68 85.37,83.43 85.37,77.02 85.17,76.82 85.17,61.39 78.07,54.29 78.07,54.09 78.34,53.83 78.34,53.65 78.12,53.43 77.94,53.43 77.68,53.7 77.48,53.7 77.28,53.5 77.28,53.3 77.74,52.84 77.74,52.65 77.54,52.45 77.35,52.45 76.89,52.91 76.69,52.91 76.49,52.71 76.49,52.51 76.95,52.05 76.95,51.86 76.75,51.66 76.56,51.66 76.1,52.12 75.9,52.12 75.27,51.49 74.32,51.49 72.57,49.73 72.57,47.14 72.03,46.6 72.03,45.07 v2(72.09,45.01)
  BOTTOM w0.14: DM1.158 71.58,44.49 v2(72.09,45.01) ; CPU1.AC32 v2(81.69,86.59)
M_A_A14: length 57.2
  L5 w0.14: v2(71.96,47.43) 72.15,47.62 72.15,49.91 74.15,51.91 75.1,51.91 78.55,55.36 78.55,55.55 78.27,55.83 78.27,56.03 78.47,56.23 78.67,56.23 78.94,55.95 79.14,55.95 79.34,56.15 79.34,56.34 79.06,56.62 79.06,56.82 79.26,57.02 79.46,57.02 79.73,56.74 79.93,56.74 80.13,56.94 80.13,57.14 79.85,57.41 79.85,57.61 80.05,57.81 80.25,57.81 80.52,57.53 80.72,57.53 80.92,57.73 80.92,57.93 80.64,58.2 80.64,58.4 80.84,58.6 81.04,58.6 81.32,58.32 81.51,58.32 84.76,61.56 84.76,76.95 85.07,77.26 85.07,78.45 84.38,79.13 84.38,82.59 83.56,83.41 83.56,83.71 82.89,84.38 82.38,84.38 81.08,85.69 81.08,86.28 81.21,86.41 81.21,86.71 81.29,86.79 81.29,86.89 v2(81.67,87.27)
  BOTTOM w0.14: v2(81.67,87.27) 81.93,87.53 CPU1.AC31 ; DM1.151 69.83,49.53 71.77,47.59 71.8,47.59 v2(71.96,47.43)
M_A_A15: length 55.8
  L5 w0.14: v2(80.78,86.59) 80.78,85.95 80.82,85.9 80.82,85.6 82.28,84.14 82.79,84.14 83.32,83.61 83.32,83.1 83.54,82.88 83.75,82.88 84.14,82.49 84.14,78.9 84.76,78.28 84.76,77.6 84.31,77.16 84.31,62.66 77.39,55.74 77.39,55.55 77.65,55.29 77.65,55.09 77.45,54.89 77.25,54.89 77,55.15 76.8,55.15 76.6,54.95 76.6,54.76 76.86,54.5 76.86,54.3 76.66,54.1 76.46,54.1 76.21,54.36 76.01,54.36 75.81,54.16 75.81,53.96 76.07,53.71 76.07,53.51 75.87,53.31 75.67,53.31 75.42,53.57 75.22,53.57 75.02,53.37 75.02,53.17 75.28,52.92 75.28,52.72 75.08,52.52 74.88,52.52 74.63,52.78 74.43,52.78 71.73,50.08 71.73,47.83 71.51,47.61 71.51,46.26 v2(71.48,46.23)
  BOTTOM w0.14: v2(80.78,86.59) 80.84,86.59 CPU1.AB32 ; v2(71.48,46.23) 71.08,45.83 DM1.156
M_A_A16: length 53.1
  L5 w0.14: v2(80.75,87.25) 80.41,86.9 80.41,86.81 80.35,86.76 80.35,86.41 80.41,86.36 80.41,85.98 80.58,85.8 80.58,85.26 81.94,83.9 82.69,83.9 83.08,83.51 83.08,82.86 83.3,82.64 83.65,82.64 83.9,82.39 83.9,80.75 83.89,80.74 83.89,62.83 71.31,50.26 71.31,48.01 71.03,47.72 71.03,45.51 v2(70.57,45.05)
  BOTTOM w0.14: v2(70.57,45.05) 70.27,45.05 70.08,44.85 DM1.152 ; v2(80.75,87.25) 80.35,86.85 CPU1.Y32
M_A_ACT_N: length 55.6
  L5 w0.14: v2(75.42,76.4) 74.69,76.4 70.51,72.23 70.51,66.49 56.47,52.45 56.47,49.12 56.57,49.02 56.57,47.03 56.71,46.89 57.55,46.89 57.69,46.75 57.69,46.47 57.55,46.33 56.71,46.33 56.57,46.19 56.57,45.77 56.7,45.64 v2(57.59,45.64)
  BOTTOM w0.076: 77.61,81.4 77.61,81.8 77.82,82.01 77.82,82.66 78.42,83.27 78.42,84 78.4,84.06 78.4,84.31 78.5,84.58 78.66,84.73 CPU1.V35
  BOTTOM w0.14: DM1.114 58.57,42.91 58.57,44.68 57.61,45.64 v2(57.59,45.64) ; 77.61,81.4 77.61,79.23 77.57,77.22 76.76,76.4 v2(75.42,76.4)
M_A_ALERT_N: length 50.1
  L5 w0.14: v2(78.05,80.33) 76.42,78.69 76.42,76.04 75.78,75.4 75.46,75.4 72.71,72.65 72.71,66.91 58.35,52.55 58.35,45.07 v2(59.08,44.35)
  BOTTOM w0.076: CPU1.W37 79.17,83.72 79.17,82.77 78.93,82.53 78.93,81.86 78.61,81.54 78.61,80.89 v2(78.05,80.33)
  BOTTOM w0.14: v2(59.08,44.35) DM1.116
M_A_BA0: length 52.4
  L5 w0.14: v2(69.03,45.03) 68.3,45.75 68.44,47.69 68.44,49.22 82.5,63.28 82.5,75.29 81.88,75.91 81.88,79.59 82.34,80.06 82.34,82.14 79.23,85.26 v2(78.97,86.54)
  BOTTOM w0.14: CPU1.W32 v2(78.97,86.54) ; v2(69.03,45.03) 69.27,45.03 69.58,44.73 DM1.150
M_A_BA1: length 55.8
  L5 w0.14: v2(69.29,46.89) 69.48,46.71 69.48,46.71 69.6,46.58 70.18,46.58 70.49,46.89 70.49,48.19 70.89,48.59 70.89,50.49 83.42,63.01 83.42,77.63 83.01,78.04 83.01,78.32 82.97,78.35 82.97,79.69 82.83,79.84 82.83,83.04 82.84,83.06 82.84,83.41 82.59,83.66 81.65,83.66 80.34,84.97 80.34,85.7 79.94,86.11 79.94,87.08 v2(80.75,87.89)
  BOTTOM w0.14: v2(69.29,46.89) 68.53,46.89 68.33,47.1 DM1.145 ; CPU1.AB31 v2(80.75,87.89)
M_A_BG0: length 54.6
  L5 w0.14: v2(78.04,81.6) 75.86,79.42 75.86,76.25 75.57,75.96 74.84,75.96 70.95,72.07 70.95,67.66 71.08,67.52 71.53,67.52 71.7,67.36 71.7,67.09 71.57,66.96 71.08,66.96 70.95,66.82 70.95,66.33 56.92,52.31 56.92,51.89 57.06,51.75 57.37,51.75 57.51,51.61 57.51,51.33 57.37,51.19 57.06,51.19 56.92,51.06 56.92,49.26 56.99,49.2 56.99,47.68 57.11,47.55 57.67,47.55 v2(57.85,47.73)
  BOTTOM w0.076: CPU1.V34 78.91,85.23 78.91,84.71 78.87,84.61 78.87,84.39 78.88,84.37 78.91,84.3 78.91,84.06 78.84,83.88 78.84,82.91 78.6,82.67 78.6,82 78.2,81.6 78.04,81.6 v2(78.04,81.6)
  BOTTOM w0.14: DM1.115 58.83,48.31 58.25,47.73 v2(57.85,47.73)
M_A_BG1: length 54.4
  L5 w0.14: v2(57.83,49) 57.65,49.19 57.64,49.19 57.37,49.45 57.37,49.83 57.93,50.38 57.93,52.72 72.29,67.09 72.29,67.93 72.15,68.07 71.5,68.07 71.36,68.21 71.36,68.49 71.5,68.63 72.15,68.63 72.29,68.77 72.29,69.05 72.15,69.19 71.5,69.19 71.36,69.33 71.36,69.61 71.5,69.75 72.15,69.75 72.29,69.89 72.29,70.17 72.15,70.31 71.5,70.31 71.36,70.45 71.36,70.73 71.5,70.87 72.15,70.87 72.29,71.01 72.29,71.29 72.15,71.43 71.5,71.43 71.36,71.57 71.36,71.84 71.5,71.98 72.15,71.98 72.29,72.12 72.29,72.82 75.15,75.68 75.72,75.68 76.14,76.1 76.14,79.05 v2(78.05,80.97)
  BOTTOM w0.076: v2(78.05,80.97) 78.45,81.36 78.45,81.61 78.77,81.93 78.77,82.6 79.01,82.84 79.01,83.85 79.07,84.03 79.07,84.33 79.05,84.39 79.05,84.62 79.08,84.71 79.08,84.93 CPU1.W35
  BOTTOM w0.14: DM1.113 58.33,49.13 58.2,49 v2(57.83,49)
M_A_CKE0: length 56.6
  L5 w0.14: v2(56.11,47.77) 55.9,47.77 55.55,47.42 55.12,47.42 54.92,47.63 54.92,48.95 55.3,49.33 55.3,49.5 55.44,49.64 55.91,49.64 56.05,49.78 56.05,50.06 55.91,50.2 55.44,50.2 55.3,50.34 55.3,50.62 55.44,50.75 55.91,50.75 56.05,50.89 56.05,51.17 55.91,51.31 55.44,51.31 55.3,51.45 55.3,51.87 70.09,66.67 70.09,72.46 74.69,77.05 v2(75.37,77.05)
  BOTTOM w0.076: CPU1.U36 78.1,84.41 78.24,84.03 78.26,83.97 78.26,83.33 77.63,82.7 77.63,82.11 77.27,81.75 77.27,81.36
  BOTTOM w0.14: DM1.109 57.33,47.65 57.08,47.4 56.48,47.4 v2(56.11,47.77) ; 77.27,81.36 77.27,77.7 76.41,76.84 75.58,76.84 v2(75.37,77.05)
M_A_CKE1: length 56.6
  L5 w0.14: v2(57.58,44.35) 56.37,44.35 56.07,44.64 56.07,44.84 56.39,45.16 56.39,45.36 56.19,45.55 55.99,45.55 55.68,45.24 55.48,45.24 55.28,45.43 55.28,45.63 55.88,46.23 55.88,46.43 55.68,46.62 55.48,46.62 54.89,46.03 54.69,46.03 54.35,46.36 54.35,51.52 69.68,66.84 69.68,72.7 v2(75.29,78.32)
  BOTTOM w0.076: CPU1.U37 78.01,83.85 78.01,83.32 77.43,82.74 77.43,82.18 76.98,81.72 76.98,81.46
  BOTTOM w0.14: DM1.110 v2(57.58,44.35) ; 76.98,81.46 76.98,78.71 76.59,78.32 v2(75.29,78.32)
M_A_CLK0: length 55.4
  L5 w0.102: v2(78.07,87.81) 78.41,87.29 78.44,87.25 78.44,85.73 79.4,84.77 79.4,84.46 79.2,84.26 79.2,84.11 79.33,83.99 79.47,83.99 79.67,84.19 79.99,84.19 80.77,83.4 80.77,83.16 81.03,82.89 81.28,82.89 82.12,82.05 82.12,80.15 81.66,79.68 81.66,75.17 81.89,74.94 81.89,63.27 68.01,49.39 68.01,47.86 67.77,47.62 67.26,47.62 v2(67.03,47.39)
  BOTTOM w0.114: DM1.137 64.33,50.26 64.46,50.12 64.46,49.75 64.78,49.43 64.78,49.17 66.34,47.61 66.8,47.61 v2(67.03,47.39) ; v2(78.07,87.81) 78.12,87.77 CPU1.V31
M_A_CLK1: length 54.2
  L5 w0.102: v2(77.13,87.75) 76.63,87.26 76.63,86.93 76.35,86.65 76.35,85.33 79.32,82.37 79.32,81.14 80.55,79.9 80.55,77.39 80.55,74.44 80.19,74.07 80.19,64.54 65.76,50.12 65.76,49.79 65.76,45.89 v2(65.51,45.64)
  BOTTOM w0.114: CPU1.T31 v2(77.13,87.75) ; DM1.138 64.58,45.1 64.82,45.35 65.51,45.64 v2(65.51,45.64)
M_A_CLK#0: length 55.5
  L5 w0.102: v2(67.03,48.28) 66.82,48.07 66.82,47.92 66.92,47.82 67.68,47.82 67.81,47.95 67.81,49.48 81.69,63.36 81.69,74.86 81.46,75.09 81.46,79.77 81.92,80.23 81.92,81.97 81.19,82.69 80.95,82.69 80.57,83.07 80.57,83.32 79.9,83.98 79.76,83.98 79.56,83.78 79.25,83.78 79,84.03 79,84.34 79.2,84.54 79.2,84.68 78.24,85.65 78.24,87.05 78.23,87.05 78.11,87.18 v2(77.96,87.18)
  BOTTOM w0.102: CPU1.V32 78.31,86.68 78.13,86.68 77.96,86.86 v2(77.96,87.18)
  BOTTOM w0.114: DM1.139 64.83,50.27 64.69,50.13 64.69,49.85 65.01,49.53 65.01,49.26 66.43,47.84 66.9,47.84 67.03,47.96 v2(67.03,48.28)
M_A_CLK#1: length 54.2
  L5 w0.102: v2(65.38,44.96) 65.62,44.96 65.97,45.31 65.97,49.71 65.97,49.71 65.97,50.03 80.39,64.45 80.39,73.99 80.75,74.35 80.75,79.98 79.52,81.22 79.52,82.45 76.55,85.42 76.55,86.56 v2(77.1,87.11)
  BOTTOM w0.114: DM1.140 65.08,43.91 64.8,44.18 64.8,45.01 64.95,45.16 65.19,45.16 v2(65.38,44.96) ; CPU1.T32 77.33,86.79 77.15,86.89 v2(77.1,87.11)
M_A_CS#0: length 59.2
  L5 w0.14: v2(83.49,86.62) 83.49,85.07 84.38,84.18 85.31,84.18 85.86,83.63 85.86,78.13 86.13,77.86 86.13,59.81 85.83,59.51 85.64,59.51 85.16,59.99 84.96,59.99 84.76,59.79 84.76,59.59 85.24,59.11 85.24,58.92 85.04,58.72 84.85,58.72 84.37,59.2 84.17,59.2 83.97,59 83.97,58.8 84.45,58.32 84.45,58.13 76.95,50.62 75.06,50.62 74.32,49.89 74.32,47.39 73.46,46.53 72.97,46.53 72.7,46.27 72.7,46.2 v2(72.52,46.02)
  BOTTOM w0.14: CPU1.AE32 83.06,86.86 83.49,86.64 v2(83.49,86.62) ; DM1.149 69.33,49.8 69.8,49 v2(72.52,46.02)
M_A_CS#1: length 60.1
  L5 w0.14: v2(74.48,45.83) 76.31,45.83 76.66,46.18 76.66,48.09 77.36,48.79 77.52,48.79 81.87,53.14 81.87,53.33 81.54,53.66 81.54,53.86 81.74,54.05 81.94,54.05 82.26,53.73 82.46,53.73 82.66,53.93 82.66,54.13 82.33,54.45 82.33,54.65 82.53,54.84 82.73,54.84 83.05,54.52 83.25,54.52 83.45,54.72 83.45,54.92 83.12,55.24 83.12,55.44 83.32,55.63 83.52,55.63 83.84,55.31 84.04,55.31 84.24,55.51 84.24,55.71 83.91,56.03 83.91,56.23 84.11,56.42 84.31,56.42 84.63,56.1 84.83,56.1 87.08,58.35 87.08,82.71 86.53,83.26 86.53,83.64 85.36,84.81 84.76,84.81 84.31,85.26 84.31,86.05 84.38,86.12 v2(84.38,86.57)
  BOTTOM w0.14: v2(74.48,45.83) 73.7,47.26 72.36,48.6 71.33,50.17 DM1.157 ; CPU1.AF32 v2(84.38,86.57)
M_A_DIMA_ODT0: length 59.3
  L5 w0.14: v2(73.24,47.01) 73.36,47.01 73.79,47.45 73.79,50.29 74.54,51.04 76.77,51.04 80.19,54.46 80.39,54.66 80.39,54.86 79.91,55.34 79.91,55.53 80.11,55.73 80.31,55.73 80.79,55.25 80.98,55.25 81.18,55.45 81.18,55.65 80.7,56.13 80.7,56.33 80.9,56.52 81.1,56.52 81.58,56.04 81.78,56.04 81.97,56.24 81.97,56.44 81.49,56.92 81.49,57.12 81.69,57.31 81.89,57.31 82.37,56.83 82.57,56.83 82.76,57.03 82.76,57.23 82.28,57.71 82.28,57.91 85.59,61.22 85.59,76.9 85.61,76.92 85.61,83.53 85.22,83.92 85.02,83.92 84.25,83.92 83.07,85.11 83.07,86.84 v2(83.49,87.27)
  BOTTOM w0.14: DM1.155 70.83,49.43 v2(73.24,47.01) ; CPU1.AE31 v2(83.49,87.27)
M_A_DIMA_ODT1: length 58.6
  L5 w0.14: v2(74.81,47.09) 74.86,47.14 74.94,47.14 75.29,47.49 75.29,47.86 75.29,47.87 75.29,48.87 76.62,50.2 77.12,50.2 77.34,50.42 77.53,50.42 77.94,50.01 78.13,50.01 78.33,50.21 78.33,50.41 77.93,50.81 77.93,51.01 78.13,51.21 78.32,51.21 78.73,50.8 78.92,50.8 79.12,51 79.12,51.2 78.72,51.6 78.72,51.8 78.92,52 79.11,52 79.52,51.6 79.71,51.6 79.91,51.79 79.91,51.99 79.51,52.39 79.51,52.59 79.71,52.79 79.9,52.79 80.31,52.39 80.51,52.39 80.7,52.58 80.7,52.78 80.3,53.18 80.3,53.38 86.55,59.63 86.55,77.94 86.84,78.23 86.84,82.51 86.23,83.11 86.23,83.6 85.4,84.43 84.53,84.43 83.95,85.01 83.95,86.8 v2(84.37,87.22)
  BOTTOM w0.14: DM1.161 72.33,49.22 74.45,47.09 v2(74.81,47.09) ; CPU1.AF31 v2(84.37,87.22)
M_A_DQ0: length 67.8
  L5 w0.114: v2(63.05,91.11) 62.51,90.57 61.36,90.57 60.29,89.51 60.29,88.63 56.64,84.99 56.64,82.68 56.82,82.5 56.82,69.48 38.08,50.75 38.08,47.06 38.08,47.06 37.41,46.39 v2(36.11,46.39)
  BOTTOM w0.076: 64.47,90.74 64.8,90.74 64.92,90.61 66.2,90.61 66.89,91.05 66.91,91.05 68.39,91.05 CPU1.A26
  BOTTOM w0.114: v2(63.05,91.11) 63.44,90.71 64.06,90.71 64.08,90.74 64.47,90.74 ; v2(36.11,46.39) 36.29,46.39 37.08,45.61 DM1.28
M_A_DQ1: length 68.9
  L5 w0.114: v2(39.63,49.03) 40.07,49.46 40.07,50.79 58.75,69.47 58.75,73.39 58.9,73.54 58.9,73.77 58.78,73.88 58.32,73.88 58.2,74 58.2,74.34 58.34,74.47 59,74.47 59.13,74.6 59.13,74.83 59.01,74.94 58.32,74.94 58.2,75.06 58.2,75.29 58.32,75.4 59.01,75.4 59.13,75.51 59.13,75.74 59.01,75.86 58.32,75.86 58.2,75.97 58.2,76.2 58.32,76.31 59.01,76.31 59.13,76.43 59.13,76.66 59.01,76.77 58.32,76.77 58.2,76.89 58.2,77.11 58.32,77.23 59.01,77.23 59.13,77.34 59.13,77.57 59.01,77.69 58.32,77.69 58.2,77.8 58.2,78.03 58.32,78.14 59.01,78.14 59.13,78.26 59.13,79.14 62.45,82.46 62.45,88.48 v2(62.49,88.52)
  BOTTOM w0.076: 66.76,90.15 67.74,90.15 67.96,89.92 68.98,89.92 69.14,89.87 69.36,89.87 69.43,89.89 69.73,89.89 69.86,89.84 70.43,89.84 70.67,89.84 70.88,90.05 CPU1.D26
  BOTTOM w0.089: 66.76,90.15 66.51,89.89 66.35,89.89 66.28,89.82 65.15,89.82 65.12,89.79 64.8,89.79 64.27,89.25 64.27,89.21
  BOTTOM w0.114: v2(62.49,88.52) 63.58,88.52 64.27,89.21 ; v2(39.63,49.03) 39.19,49.47 39.19,50.19 39.33,50.32 DM1.37
M_A_DQ2: length 68.6
  L5 w0.114: v2(40.6,44.45) 41.17,44.45 41.48,44.76 41.48,46.71 41.6,46.83 41.95,46.83 42.07,46.94 42.07,47.17 41.95,47.28 41.6,47.28 41.12,47.76 41.12,50.25 61.83,70.96 61.83,76.44 61.71,76.56 61.48,76.56 61.37,76.67 61.37,76.9 61.48,77.01 61.71,77.01 61.83,77.13 61.83,77.36 61.71,77.47 61.48,77.47 61.37,77.59 61.37,77.81 61.48,77.93 61.71,77.93 61.83,78.04 61.83,78.27 61.71,78.39 61.48,78.39 61.37,78.5 61.37,78.73 61.48,78.84 61.71,78.84 61.83,78.96 61.83,79.19 61.71,79.3 61.48,79.3 61.37,79.42 61.37,79.64 61.48,79.76 61.71,79.76 61.83,79.87 61.83,80.38 63.48,82.04 63.48,87.3 64.26,88.08 66.72,88.08 66.83,87.96 66.83,87.34 66.94,87.22 67.17,87.22 67.29,87.34 67.29,87.96 67.4,88.08 67.59,88.08 67.72,88.21 67.72,88.83 v2(67.53,89.02)
  BOTTOM w0.076: CPU1.D28 70.27,89.18 69.33,89.18 69.08,89.04 68.7,89.04 68.49,89.25 67.76,89.25 v2(67.53,89.02)
  BOTTOM w0.114: v2(40.6,44.45) 40.58,44.43 DM1.42
M_A_DQ3: length 68
  L5 w0.114: v2(36.07,44.43) 38.43,46.79 38.43,50.6 57.17,69.35 57.17,78.68 61.42,82.93 61.42,86.41 60.63,87.2 60.63,89.36 61.43,90.16 63.78,90.16 v2(64.76,89.18)
  BOTTOM w0.076: CPU1.C28 70.22,89.47 70.12,89.57 69.7,89.72 69.46,89.72 69.42,89.71 69.41,89.7 69.11,89.7 68.95,89.76 67.89,89.76 67.82,89.83 66.86,89.83
  BOTTOM w0.089: v2(64.76,89.18) 65.22,89.65 66.36,89.65 66.42,89.71 66.58,89.71 66.7,89.83 66.86,89.83
  BOTTOM w0.114: DM1.24 36.08,44.43 v2(36.07,44.43)
M_A_DQ4: length 66.1
  L5 w0.114: v2(37.3,48.32) 37.74,48.76 37.74,50.89 56.48,69.63 56.48,82.36 56.3,82.54 56.3,85.13 59.13,87.96 59.13,88.12 58.96,88.29 58.96,88.45 59.12,88.61 59.28,88.61 59.45,88.44 59.61,88.44 59.77,88.6 59.77,88.77 59.5,89.04 59.5,89.2 61.21,90.91 62.19,90.91 62.87,91.59 64.09,91.59 v2(64.42,91.27)
  BOTTOM w0.076: v2(64.42,91.27) 64.59,91.09 64.69,91.09 65,90.78 66.08,90.78 66.73,91.19 66.89,91.22 68.42,91.22 69.06,91.01 CPU1.B26
  BOTTOM w0.114: v2(37.3,48.32) 36.95,48.32 36.33,48.95 DM1.25
M_A_DQ5: length 67.2
  L5 w0.114: v2(65.8,91.22) 66.81,91.22 66.89,91.3 66.89,91.97 66.77,92.1 64.12,92.1 63.95,91.93 62.73,91.93 62.05,91.26 61.07,91.26 59.16,89.34 59.16,89.15 57.96,87.96 57.96,87.8 58.14,87.62 58.14,87.46 57.98,87.29 57.82,87.29 57.64,87.47 57.48,87.47 57.31,87.31 57.31,87.15 57.49,86.97 57.49,86.81 57.33,86.65 57.17,86.65 56.99,86.83 56.83,86.83 56.67,86.66 56.67,86.5 56.85,86.32 56.85,86.16 55.96,85.27 55.96,82.39 56.14,82.22 56.14,69.77 37.4,51.03 37.4,49.76 v2(37.3,49.67)
  BOTTOM w0.076: CPU1.C26 69.74,91.09 69.25,91.13 68.45,91.38 66.88,91.38 v2(65.8,91.22)
  BOTTOM w0.114: DM1.29 37.33,49.69 v2(37.3,49.67)
M_A_DQ6: length 67.4
  L5 w0.114: v2(40.57,45.72) 40.75,45.53 41,45.53 41.12,45.66 41.12,46.74 40.78,47.08 40.78,50.47 61.03,70.73 61.03,71.82 61.14,71.94 61.37,71.94 61.48,72.05 61.48,72.28 61.37,72.4 61.14,72.4 61.03,72.51 61.03,72.74 61.14,72.85 61.37,72.85 61.48,72.97 61.48,73.2 61.37,73.31 61.14,73.31 61.03,73.42 61.03,73.65 61.14,73.77 61.37,73.77 61.48,73.88 61.48,74.11 61.37,74.22 61.14,74.22 61.03,74.34 61.03,74.57 61.14,74.68 61.37,74.68 61.48,74.8 61.48,75.02 61.37,75.14 61.14,75.14 61.03,75.25 61.03,75.48 61.14,75.6 61.37,75.6 61.48,75.71 61.48,75.94 61.37,76.05 61.14,76.05 61.03,76.17 61.03,80.07 63.13,82.18 63.13,87.44 64.12,88.42 66.74,88.42 66.87,88.55 66.87,88.93 v2(66.66,89.13)
  BOTTOM w0.076: 67.29,89.36 67.35,89.42 68.56,89.42 68.76,89.21 69.06,89.21 69.24,89.32 69.52,89.47 CPU1.B28
  BOTTOM w0.089: 67.29,89.36 66.89,89.36 v2(66.66,89.13)
  BOTTOM w0.114: v2(40.57,45.72) 40.36,45.72 40.02,46.06 39.7,46.06 39.58,45.94 DM1.38
M_A_DQ7: length 66.9
  L5 w0.114: v2(66.03,89.18) 66.03,88.89 65.9,88.77 63.97,88.77 63.66,88.45 63.5,88.45 63.34,88.6 63.18,88.6 63.02,88.44 63.02,88.28 63.17,88.12 63.17,87.96 62.79,87.58 62.79,82.32 60.68,80.21 60.68,79.87 60.57,79.75 60.3,79.75 60.16,79.62 60.16,79.41 60.27,79.3 60.57,79.3 60.68,79.18 60.68,78.5 60.57,78.38 60.45,78.38 60.34,78.27 60.34,78.04 60.45,77.93 60.57,77.93 60.68,77.81 60.68,77.58 60.57,77.47 60.45,77.47 60.34,77.36 60.34,77.13 60.45,77.01 60.57,77.01 60.68,76.9 60.68,76.67 60.57,76.56 60.45,76.56 60.34,76.44 60.34,76.21 60.45,76.1 60.57,76.1 60.68,75.98 60.68,70.87 40.42,50.6 40.42,47.12 40.29,46.99 39.99,46.99 39.56,47.43 v2(39.56,47.75)
  BOTTOM w0.076: 67.07,89.63 67.78,89.63 67.82,89.59 68.8,89.59 CPU1.A28
  BOTTOM w0.089: 67.07,89.63 66.97,89.54 66.66,89.54 66.65,89.53 66.5,89.53 66.43,89.47 66.32,89.47 v2(66.03,89.18)
  BOTTOM w0.114: v2(39.56,47.75) 39.56,46.99 39.78,46.76 40.2,46.76 40.33,46.89 DM1.41
M_A_DQ8: length 59.2
  L5 w0.114: v2(65.26,87.58) 64.16,86.48 64.16,81.67 62.64,80.14 62.64,70.62 46.49,54.47 46.49,54.31 46.8,54 46.8,53.84 46.63,53.67 46.47,53.67 46.16,53.98 46,53.98 45.84,53.82 45.84,53.66 46.15,53.35 46.15,53.19 45.99,53.03 45.83,53.03 45.59,53.26 45.43,53.26 45.27,53.1 45.27,52.94 45.5,52.7 45.5,52.54 42.83,49.87 42.83,48.69 42.6,48.46 v2(41.91,48.46)
  BOTTOM w0.076: 67.09,88.16 67.51,88.16 67.65,88.3 68.28,88.3 68.28,88.3 68.51,88.3 68.72,88.51 69.04,88.51 69.52,88.31 CPU1.B30
  BOTTOM w0.089: 67.09,88.16 65.47,88.16 65.26,87.94 v2(65.26,87.58)
  BOTTOM w0.114: DM1.49 42.33,50.26 42.4,50.19 42.4,48.95 v2(41.91,48.46)
M_A_DQ9: length 60.3
  L5 w0.114: v2(42.09,44.98) 42.1,44.98 43.51,46.4 43.51,49.58 47.73,53.8 47.73,54.74 63.33,70.33 63.33,79.86 64.85,81.38 64.85,85.91 65.15,86.22 66.13,86.22 66.25,86.1 66.61,86.1 67.08,86.57 v2(67.08,86.63)
  BOTTOM w0.076: v2(67.08,86.63) 67.46,87.01 67.58,87.01 68.01,87.43 68.93,87.43 69.13,87.35 69.37,87.35 69.43,87.37 69.72,87.37 69.85,87.32 69.85,87.32 70.67,87.32 70.88,87.53 CPU1.D30
  BOTTOM w0.114: v2(42.09,44.98) 41.58,44.47 DM1.46
M_A_DQ10: length 59.2
  L5 w0.114: v2(67.59,84.15) 67.59,83.34 66.56,82.31 66.56,80.67 65.04,79.15 65.04,69.59 54.12,58.67 54.12,58.5 54.41,58.21 54.41,58.05 54.25,57.89 54.09,57.89 53.8,58.18 53.63,58.18 53.47,58.02 53.47,57.86 53.77,57.56 53.77,57.4 53.61,57.24 53.44,57.24 53.15,57.53 52.99,57.53 52.83,57.37 52.83,57.21 53.12,56.92 53.12,56.75 46.55,50.18 46.55,46.45 46.46,46.36 46.46,44.88 46.23,44.65 45.57,44.65 v2(44.58,45.65)
  BOTTOM w0.089: v2(67.59,84.15) 67.59,84.78 68.62,85.81 68.62,85.81 68.72,85.9 68.87,85.9 CPU1.B33
  BOTTOM w0.114: DM1.62 45.58,45.44 45.37,45.65 v2(44.58,45.65)
M_A_DQ11: length 58.1
  L5 w0.114: v2(44.58,44.34) 44.06,44.34 43.9,44.5 43.9,45.83 44.15,46.08 45.7,46.08 46.21,46.59 46.21,50.32 52.5,56.62 52.5,56.78 52.21,57.08 52.21,57.24 64.7,69.73 64.7,79.29 66.22,80.81 66.22,82.5 67.18,83.46 67.18,84.32 67.24,84.38 67.24,85.09 v2(67.16,85.17)
  BOTTOM w0.076: v2(67.16,85.17) 67.37,85.17 68.25,86.05 68.62,86.05 68.98,86.41 69.1,86.53 69.29,86.61 69.37,86.65 69.39,86.66 70.28,86.66 CPU1.D32
  BOTTOM w0.114: v2(44.58,44.34) DM1.58
M_A_DQ12: length 57.9
  L5 w0.114: v2(66.12,87.58) 65.16,86.62 65.07,86.62 64.51,86.06 64.51,81.52 62.98,80 62.98,70.48 47.39,54.88 47.39,53.94 43.17,49.73 43.17,47.29 v2(42.14,46.25)
  BOTTOM w0.076: 67.24,87.91 67.49,87.91 67.72,88.14 68.35,88.14 68.35,88.14 68.58,88.14 68.7,88.25 CPU1.A30
  BOTTOM w0.089: v2(66.12,87.58) 66.45,87.91 67.24,87.91
  BOTTOM w0.114: DM1.50 42.58,45.82 v2(42.14,46.25)
M_A_DQ13: length 58.9
  L5 w0.114: v2(41.56,49.63) 41.56,50.02 42.63,51.09 42.79,51.09 43.1,50.78 43.26,50.78 43.42,50.95 43.42,51.11 43.11,51.42 43.11,51.58 43.27,51.74 43.44,51.74 43.74,51.43 43.91,51.43 44.07,51.59 44.07,51.75 43.76,52.06 43.76,52.22 43.92,52.39 44.08,52.39 44.39,52.08 44.55,52.08 44.71,52.24 44.71,52.4 44.41,52.71 44.41,52.87 62.3,70.76 62.3,80.28 63.82,81.81 63.82,87.02 v2(64.08,87.28)
  BOTTOM w0.076: 67.32,88.34 67.44,88.47 68.21,88.47 68.45,88.47 68.65,88.67 69.08,88.67 69.18,88.63 69.23,88.61 69.73,88.61 70.08,88.25 CPU1.C30
  BOTTOM w0.089: v2(64.08,87.28) 64.08,87.71 64.71,88.34 67.32,88.34
  BOTTOM w0.114: v2(41.56,49.63) 41.34,49.86 41.34,50.28 41.33,50.29 DM1.45
M_A_DQ14: length 57.3
  L5 w0.114: v2(44.25,47.04) 44.25,46.69 44.51,46.43 45.55,46.43 45.86,46.75 45.86,50.47 51.84,56.45 51.84,57.36 64.35,69.87 64.35,79.43 65.88,80.95 65.88,82.77 66.37,83.26 66.37,83.29 66.37,83.29 66.37,85.05 v2(66.53,85.21)
  BOTTOM w0.076: 67.91,86.22 68.55,86.22 68.82,86.48 69,86.67 69.29,86.8 69.56,86.96 CPU1.B32
  BOTTOM w0.089: v2(66.53,85.21) 67.54,86.22 67.91,86.22
  BOTTOM w0.114: DM1.59 44.83,47.44 44.42,47.04 v2(44.25,47.04)
M_A_DQ15: length 57.9
  L5 w0.114: v2(46.99,47.52) 47.55,47.52 47.7,47.68 47.7,50.85 55.12,58.27 55.12,58.43 54.82,58.72 54.82,58.88 54.98,59.05 55.15,59.05 55.44,58.75 55.6,58.75 55.76,58.91 55.76,59.07 55.47,59.37 55.47,59.53 55.63,59.69 55.79,59.69 56.09,59.4 56.25,59.4 56.49,59.64 56.49,59.82 56.21,60.1 56.21,60.28 65.38,69.44 65.38,79 66.88,80.5 66.88,82.12 68.56,83.8 68.56,85.8 v2(67.74,86.62)
  BOTTOM w0.076: v2(67.74,86.62) 68.4,87.27 68.9,87.27 69.07,87.2 69.08,87.18 69.4,87.18 69.41,87.19 69.46,87.21 69.69,87.21 69.74,87.19 69.98,86.95 CPU1.C32
  BOTTOM w0.114: v2(46.99,47.52) 45.93,48.59 45.93,50.06 45.83,50.17 DM1.63
M_A_DQ16: length 64
  L5 w0.114: v2(46.95,45.61) 47.87,45.61 49.96,47.7 49.96,50.99 64.05,65.07 64.05,65.23 63.79,65.48 63.79,65.65 63.95,65.81 64.12,65.81 64.37,65.55 64.53,65.55 64.69,65.72 64.69,65.88 64.44,66.13 64.44,66.29 66.9,68.75 66.9,77.21 67.77,78.08 67.77,80.54 69.62,82.39 69.62,90.58 71.66,92.61 v2(73.31,92.61)
  BOTTOM w0.114: DM1.66 46.58,44.11 46.53,44.15 46.53,45.19 v2(46.95,45.61) ; v2(73.31,92.61) 73.48,92.78 CPU1.J22
M_A_DQ17: length 66.6
  L5 w0.114: v2(73.18,90.63) 73,90.45 73,86.81 73.41,86.4 73.41,85.52 73.78,85.16 73.78,84.47 73.89,84.35 74.06,84.35 74.17,84.24 74.17,84.01 74.06,83.9 73.89,83.9 73.78,83.78 73.78,83.55 73.89,83.44 74.06,83.44 74.17,83.32 74.17,83.1 74.06,82.98 73.89,82.98 73.78,82.87 73.78,82.64 73.89,82.52 74.06,82.52 74.17,82.41 74.17,82.18 74.06,82.07 73.89,82.07 73.65,81.82 73.65,81.66 73.82,81.49 73.82,81.33 73.65,81.17 73.49,81.17 73.32,81.34 73.16,81.34 73,81.18 73,81.02 73.17,80.85 73.17,80.69 73.01,80.52 72.85,80.52 72.68,80.69 72.52,80.69 72.35,80.53 72.35,80.37 72.52,80.2 72.52,80.04 72.36,79.88 72.2,79.88 72.03,80.05 71.87,80.05 71.15,79.33 71.15,75.59 68.69,73.13 68.69,67.26 53.33,51.91 53.33,46.31 53.22,46.19 52.37,46.19 52.25,46.08 52.25,45.85 52.37,45.73 53.22,45.73 53.33,45.62 53.33,45.28 53.01,44.96 52.1,44.96 v2(51.17,45.89)
  BOTTOM w0.114: v2(51.17,45.89) 50.87,45.89 50.08,45.1 DM1.80 ; v2(73.18,90.63) 73.07,90.95 CPU1.H25
M_A_DQ18: length 63.3
  L5 w0.114: v2(48.31,47.6) 49.28,48.57 49.28,51.27 61.41,63.4 61.41,63.56 61.23,63.74 61.23,63.9 61.4,64.06 61.56,64.06 61.73,63.89 61.89,63.89 62.06,64.05 62.06,64.21 61.77,64.5 61.77,64.66 61.93,64.82 62.09,64.82 62.38,64.53 62.54,64.53 62.7,64.7 62.7,64.86 62.42,65.14 62.42,65.3 66.2,69.08 66.2,78.82 67.34,79.96 67.34,81.48 69.05,83.2 69.05,90.87 71.34,93.16 72.07,93.16 v2(72.48,93.57)
  BOTTOM w0.114: CPU1.G22 v2(72.48,93.57) ; v2(48.31,47.6) 47.29,48.62 47.06,48.62 46.57,49.11 46.57,49.95 46.83,50.2 DM1.67
M_A_DQ19: length 63.2
  L5 w0.114: v2(73.15,93.6) 72.42,92.88 71.52,92.88 69.31,90.67 69.31,82.97 67.55,80.72 67.55,79.65 66.54,77.63 66.54,68.94 63.38,65.78 63.38,64.88 49.62,51.13 49.62,48.29 48.52,47.19 v2(46.99,46.88)
  BOTTOM w0.114: DM1.70 47.58,46.3 v2(46.99,46.88) ; CPU1.H22 v2(73.15,93.6)
M_A_DQ20: length 67
  L5 w0.114: v2(51.19,48.43) 52.47,48.43 52.64,48.6 52.64,49.28 52.53,49.4 51.68,49.4 51.57,49.51 51.57,49.74 51.68,49.85 52.53,49.85 52.64,49.97 52.64,50.2 52.53,50.31 51.68,50.31 51.57,50.42 51.57,50.65 51.68,50.77 52.53,50.77 52.64,50.88 52.64,51.11 52.53,51.22 52.24,51.22 52.12,51.34 52.12,51.57 52.24,51.68 52.53,51.68 52.64,51.8 52.64,52.19 68,67.55 68,75.21 69.22,76.43 69.22,79.53 70.79,81.1 71.71,81.1 71.85,81.25 71.85,81.59 71.74,81.71 71.11,81.71 71,81.82 71,82.05 71.11,82.16 71.84,82.16 71.95,82.28 71.95,82.51 71.84,82.62 71.11,82.62 71,82.74 71,82.96 71.11,83.08 71.84,83.08 71.95,83.19 71.95,83.42 71.84,83.54 71.11,83.54 71,83.65 71,83.88 71.11,83.99 71.84,83.99 71.95,84.11 71.95,84.34 71.84,84.45 71.11,84.45 71,84.56 71,84.79 71.11,84.91 71.74,84.91 71.85,85.02 71.85,85.78 71.18,86.45 71.18,90.27 v2(71.48,90.57)
  BOTTOM w0.114: v2(51.19,48.43) 50.9,48.43 50.67,48.66 50.67,49.8 50.83,49.95 DM1.83 ; CPU1.F25 71.53,90.66 71.49,90.62 71.49,90.57 v2(71.48,90.57)
M_A_DQ21: length 65.2
  L5 w0.114: v2(51.17,44.57) 51.17,44.32 51.3,44.2 52.94,44.2 53.67,44.93 53.67,51.77 69.03,67.12 69.03,72.81 72.72,76.5 72.72,79.6 74.77,81.65 75.28,81.65 75.42,81.79 75.42,81.99 75.3,82.11 74.77,82.11 74.65,82.22 74.65,82.45 74.77,82.56 75.28,82.56 75.42,82.7 75.42,82.91 75.3,83.02 74.77,83.02 74.65,83.14 74.65,83.36 74.77,83.48 75.28,83.48 75.42,83.62 75.42,83.82 75.3,83.94 74.77,83.94 74.65,84.05 74.65,84.28 74.77,84.39 75.28,84.39 75.42,84.53 75.42,84.74 75.3,84.85 74.77,84.85 73.71,85.9 73.71,87.2 73.88,87.37 73.88,90.56 v2(73.82,90.63)
  BOTTOM w0.114: DM1.84 51.08,44.47 v2(51.17,44.57) ; CPU1.J25 73.82,90.74 v2(73.82,90.63)
M_A_DQ22: length 63.8
  L5 w0.114: v2(72.44,90.65) 72.08,90.28 72.08,86.56 72.88,85.76 72.88,85.1 72.99,84.99 73.24,84.99 73.36,84.88 73.36,84.65 73.24,84.53 72.99,84.53 72.88,84.42 72.88,84.19 72.99,84.08 73.24,84.08 73.36,83.96 73.36,83.73 73.24,83.62 72.99,83.62 72.88,83.5 72.88,82.32 72.99,82.21 73.17,82.21 73.28,82.09 73.28,81.87 73.17,81.75 72.99,81.75 70.71,79.47 70.71,75.79 68.34,73.42 68.34,67.41 52.99,52.05 52.99,47.99 52.87,47.88 51.83,47.88 51.72,47.77 51.72,47.54 51.83,47.42 52.87,47.42 52.99,47.31 52.99,46.97 52.86,46.84 51.5,46.84 v2(51.19,47.16)
  BOTTOM w0.114: v2(51.19,47.16) 50.89,47.16 49.82,48.23 49.82,51.09 DM1.79 ; CPU1.G25 72.18,90.92 72.43,90.67 72.43,90.66 v2(72.44,90.65)
M_A_DQ23: length 63
  L5 w0.114: v2(48.24,48.9) 48.92,49.58 48.92,51.03 48.94,51.04 48.94,51.41 57.37,59.85 57.37,59.85 57.51,59.99 57.51,60.15 57.22,60.43 57.22,60.6 57.38,60.76 57.54,60.76 57.83,60.47 57.99,60.47 58.15,60.63 58.15,60.79 57.87,61.08 57.87,61.24 58.03,61.4 58.19,61.4 58.48,61.12 58.64,61.12 58.8,61.28 58.8,61.44 58.51,61.73 58.51,61.89 58.68,62.05 58.84,62.05 59.12,61.76 59.29,61.76 59.45,61.93 59.45,62.09 59.16,62.37 59.16,62.54 59.32,62.7 59.48,62.7 59.77,62.41 59.93,62.41 60.09,62.57 60.09,62.73 59.81,63.02 59.81,63.18 59.97,63.34 60.13,63.34 60.42,63.06 60.58,63.06 60.74,63.22 60.74,63.38 60.45,63.67 60.45,63.83 65.85,69.23 65.85,78.99 67.12,80.26 67.12,81.83 68.84,83.54 68.84,91.1 71.33,93.6 v2(71.83,93.6)
  BOTTOM w0.114: v2(71.83,93.6) 71.53,93.29 CPU1.F22 ; DM1.71 47.83,49.31 v2(48.24,48.9)
M_A_DQ24: length 74.8
  L5 w0.114: v2(67.81,94.26) 67.81,94.86 66.42,96.24 64.98,96.24 64.86,96.13 64.86,95.9 64.75,95.78 64.52,95.78 64.4,95.9 64.4,96.13 64.29,96.24 64.06,96.24 63.95,96.13 63.95,95.9 63.83,95.78 63.6,95.78 63.49,95.9 63.49,96.13 63.38,96.24 63.15,96.24 63.03,96.13 63.03,95.9 62.92,95.78 62.69,95.78 62.58,95.9 62.58,96.13 62.46,96.24 62.23,96.24 62.12,96.13 62.12,95.9 62,95.78 61.78,95.78 61.66,95.9 61.66,96.13 61.55,96.24 61.2,96.24 52.48,87.52 52.48,71.2 31.42,50.14 31.42,49.56 31.55,49.44 v2(31.83,49.44)
  BOTTOM w0.076: CPU1.D22 70.71,93.37 70.34,93.54 69.25,93.64 69.06,93.7 68.4,93.86 68.1,93.97
  BOTTOM w0.089: 68.1,93.97 v2(67.81,94.26)
  BOTTOM w0.114: DM1.7 v2(31.83,49.44)
M_A_DQ25: length 74.6
  L5 w0.114: v2(32.55,45.11) 32.95,45.51 32.95,45.64 32.95,45.64 32.95,46 32.95,46.01 32.95,46.24 32.98,46.28 32.98,46.64 32.95,46.67 32.95,48.35 32.95,48.35 32.95,48.86 32.95,48.86 32.95,50.21 53.51,70.77 53.51,87.09 61.16,94.74 64.65,94.74 v2(65.16,94.23)
  BOTTOM w0.076: CPU1.C22 69.68,93.03 69.51,93.03 69.33,93.06 69.17,93.06 68.99,93.03 68.84,93.03 67.48,93.5
  BOTTOM w0.089: 67.48,93.5 66.98,93.52 66.53,93.8 66.02,93.8
  BOTTOM w0.114: v2(65.16,94.23) 64.96,94.04 64.96,93.83 65.09,93.7 65.92,93.7 66.02,93.8 ; DM1.8 32.08,45.11 32.22,45.26 32.4,45.26 v2(32.55,45.11)
M_A_DQ26: length 74.9
  L5 w0.114: v2(35.33,48.16) 35.67,47.83 35.85,47.83 36.15,48.13 36.15,51.47 54.88,70.2 54.88,86.52 60.64,92.29 61.26,92.29 v2(62.03,93.06)
  BOTTOM w0.076: 65.98,91.68 66,91.66 66.02,91.66 66.07,91.64 66.14,91.61 67.66,91.61 68.64,91.57 69.06,91.57 69.08,91.57 69.23,91.62 69.71,91.75 CPU1.C24
  BOTTOM w0.089: 65.98,91.68 65.33,91.68
  BOTTOM w0.114: DM1.17 34.33,50.01 34.48,49.86 34.48,49.11 34.55,49.04 34.55,47.8 34.67,47.68 34.94,47.68 35.33,48.07 v2(35.33,48.16) ; 65.33,91.68 65.26,91.68 65.24,91.71 62.27,91.71 62.13,91.57 62.13,90.82 62.02,90.7 61.79,90.7 61.68,90.82 61.68,91.58 61.56,91.69 60.96,91.69 60.84,91.82 60.84,92.48 60.96,92.61 61.58,92.61 62.02,93.06 v2(62.03,93.06)
M_A_DQ27: length 75.9
  L5 w0.114: v2(35.32,49.46) 34.88,49.02 34.57,49.02 34.47,49.12 34.47,50.28 34.78,50.59 34.94,50.59 35.32,50.21 35.48,50.21 35.64,50.37 35.64,50.53 35.27,50.91 35.27,51.07 54.54,70.34 54.54,86.66 60.92,93.05 v2(61.4,93.05)
  BOTTOM w0.076: CPU1.D24 70.88,92.71 70.67,92.92 70,92.92 69.72,92.87 69.71,92.87 69.5,92.87 69.31,92.89 69.19,92.89 69,92.87 68.81,92.87 67.56,93.28 67.53,93.31 67.47,93.33 67.44,93.33 66.86,93.33
  BOTTOM w0.114: 66.86,93.33 65.02,93.33 64.6,93.75 64.6,94.2 64.48,94.31 64.14,94.31 64.02,94.2 64.02,93.64 63.91,93.52 63.68,93.52 63.57,93.64 63.57,94.2 63.45,94.31 63.22,94.31 63.11,94.2 63.11,93.64 63,93.52 62.77,93.52 62.65,93.64 62.65,94.2 62.54,94.31 62.31,94.31 62.2,94.2 62.2,93.64 62.08,93.52 61.85,93.52 61.74,93.64 61.74,94.2 61.62,94.31 61.27,94.31 61.08,94.13 61.08,93.36 v2(61.4,93.05) ; v2(35.32,49.46) 35.33,49.46 DM1.21
M_A_DQ28: length 73.3
  L5 w0.114: v2(32.54,46.46) 32.61,47.93 32.61,48.21 32.61,50.35 53.17,70.91 53.17,87.23 61.03,95.1 65.49,95.1 66.04,94.67 66.3,94.41 66.3,94.39 v2(66.5,94.23)
  BOTTOM w0.076: v2(66.5,94.23) 67.04,93.69 67.51,93.67 CPU1.A22
  BOTTOM w0.114: DM1.4 31.08,45.37 32.16,46.46 v2(32.54,46.46)
M_A_DQ29: length 73.9
  L5 w0.114: v2(31.8,48.11) 32.14,48.11 32.26,48.24 32.26,49.14 32.26,50.5 52.82,71.06 52.82,87.37 60.89,95.44 65.22,95.44 65.34,95.56 65.34,95.78 65.45,95.9 65.68,95.9 65.79,95.78 65.79,95.56 65.91,95.44 66.67,95.44 67.13,94.97 v2(67.13,94.24)
  BOTTOM w0.076: CPU1.B22 69.06,93.52 69.04,93.53 67.75,93.8
  BOTTOM w0.089: v2(67.13,94.24) 67.48,93.89 67.66,93.89 67.75,93.8
  BOTTOM w0.114: DM1.3 30.83,48.45 31.17,48.11 v2(31.8,48.11)
M_A_DQ30: length 73.4
  L5 w0.114: v2(34.08,44.56) 34.4,44.23 35.51,44.23 35.63,44.36 35.63,44.83 35.52,44.94 35.07,44.94 34.95,45.06 34.95,45.28 35.07,45.4 35.52,45.4 35.63,45.51 35.63,46.54 35.93,46.83 36.67,46.83 36.88,47.04 36.88,47.23 37,47.35 37.49,47.35 37.62,47.48 37.62,47.7 37.49,47.83 37.01,47.83 36.83,48.01 36.83,51.18 55.57,69.92 55.57,86.24 60.93,91.6 61.91,91.6 62.58,92.28 63.81,92.28 63.97,92.44 64.44,92.44 64.57,92.57 v2(64.57,93.04)
  BOTTOM w0.076: CPU1.A24 66.49,91.99
  BOTTOM w0.089: 66.49,91.99 66.2,91.99 65.83,92.36 64.8,92.36 64.57,92.58 v2(64.57,93.04)
  BOTTOM w0.114: DM1.16 v2(34.08,44.56)
M_A_DQ31: length 75
  L5 w0.114: v2(34.04,45.96) 34.32,45.68 34.64,45.68 34.76,45.81 34.76,46.26 34.84,46.33 34.84,46.49 34.52,46.8 34.52,46.97 34.67,47.12 34.86,47.12 35.16,46.81 35.32,46.81 36.49,47.98 36.49,51.33 55.22,70.06 55.22,86.38 60.79,91.94 61.76,91.94 62.44,92.62 62.86,92.62 v2(63.3,93.06)
  BOTTOM w0.076: CPU1.B24 69.03,91.73 68.88,91.73 67.27,91.8 66.24,91.8 66.15,91.8
  BOTTOM w0.089: 66.15,91.8 65.64,92.05
  BOTTOM w0.114: DM1.20 35.08,46.2 34.95,46.33 34.4,46.33 v2(34.04,45.96) ; v2(63.3,93.06) 62.97,92.74 62.97,92.23 63.15,92.05 63.55,92.05 63.66,92.17 63.66,92.48 63.78,92.6 64.01,92.6 64.12,92.48 64.12,92.17 64.24,92.05 65.64,92.05
M_A_DQ32: length 53.9
  L3 w0.089: v2(84.87,48.14) 85.08,47.93 85.32,47.93 85.42,48.03 85.42,48.6 85.33,48.69 84.78,48.69 84.69,48.78 84.69,48.97 84.78,49.06 85.33,49.06 85.42,49.14 85.42,49.33 85.33,49.42 84.78,49.42 84.69,49.51 84.69,49.7 84.78,49.79 85.33,49.79 85.42,49.88 85.42,50.07 85.33,50.16 84.78,50.16 84.69,50.25 84.69,50.44 84.78,50.53 85.33,50.53 85.42,50.62 85.42,51.38 67.39,69.42 67.39,75.85 68.48,76.94 68.48,78.13 v2(68.21,78.41)
  BOTTOM w0.076: 71.8,82.54 72.02,82.75 72.52,83.28 72.89,83.78 CPU1.H37
  BOTTOM w0.089: 71.8,82.54 71.33,82.06 70.77,82.06
  BOTTOM w0.114: v2(84.87,48.14) 84.96,48.23 84.96,48.51 84.87,48.6 84.87,48.86 84.83,48.91 DM1.211 ; v2(68.21,78.41) 69.19,79.39 69.19,80.9 70.35,82.06 70.77,82.06
M_A_DQ33: length 54.7
  L3 w0.089: v2(85.04,44.34) 84.85,44.15 84.13,44.15 84.01,44.27 84.01,46.46 83.47,47 83.47,52.21 66.59,69.08 66.59,76.93 66.98,77.32 66.98,79.17 v2(68.18,80.36)
  BOTTOM w0.076: CPU1.H34 72.83,85.52 72.69,85.23 72.69,84.28 72.62,84.15 72.59,84.1 72.34,83.85 72.34,83.64 72.06,83.36 71.99,83.36 71.24,82.62
  BOTTOM w0.114: 71.24,82.62 71.23,82.61 70.09,82.61 68.18,80.7 v2(68.18,80.36) ; DM1.212 85.08,44.3 v2(85.04,44.34)
M_A_DQ34: length 56.9
  L3 w0.089: v2(69.64,78.79) 70.13,78.79 70.26,78.67 70.26,75.79 70.17,75.7 69.88,75.7 69.79,75.61 69.79,75.42 69.88,75.33 70.17,75.33 70.26,75.24 70.26,75.05 70.17,74.96 69.88,74.96 69.79,74.88 69.79,74.69 69.88,74.6 70.17,74.6 70.26,74.51 70.26,74.32 70.17,74.23 69.88,74.23 69.79,74.14 69.79,73.95 69.88,73.86 70.17,73.86 70.26,73.77 70.26,73.5 70.17,73.42 69.88,73.42 69.79,73.33 69.79,73.14 69.88,73.05 70.17,73.05 70.26,72.96 70.26,72.77 70.17,72.68 69.88,72.68 69.79,72.59 69.79,72.4 69.88,72.31 70.17,72.31 70.26,72.22 70.26,72.03 70.17,71.94 69.88,71.94 69.79,71.85 69.79,71.66 69.88,71.57 70.17,71.57 70.26,71.48 70.26,69.01 89.57,49.71 v2(89.57,47.85)
  BOTTOM w0.076: CPU1.K34 73.55,85.81 73.34,85.6 73.34,84.78 73.35,84.76 73.39,84.65 73.39,84.35 73.39,84.35 73.37,84.3 73.37,84.06 73.39,84 73.39,83.54 72.96,83.11
  BOTTOM w0.089: 72.96,83.11 72.49,82.64
  BOTTOM w0.114: 72.49,82.64 71.41,81.56 70.92,81.56 69.75,80.39 69.75,78.9 v2(69.64,78.79) ; DM1.229 89.33,48.65 89.57,48.41 v2(89.57,47.85)
M_A_DQ35: length 55.9
  L3 w0.089: v2(88.59,44.98) 88.88,44.98 89,45.11 89,49.89 69.45,69.45 69.45,69.96 69.57,70.09 69.9,70.09 69.99,70.18 69.99,70.37 69.9,70.46 69.54,70.46 69.42,70.57 69.42,70.74 69.51,70.83 69.9,70.83 69.99,70.92 69.99,71.11 69.9,71.19 69.61,71.19 69.52,71.28 69.52,75.01 69.4,75.13 69.22,75.13 69.07,74.99 v2(69.07,74.99)
  BOTTOM w0.076: CPU1.K35 74.58,84.85 74.58,84.22 74.69,84.02 74.69,82.69 73.76,81.76
  BOTTOM w0.114: 73.76,81.76 73.62,81.76 71.22,79.36 71.22,76.93 69.42,75.13 69.22,75.13 69.07,74.99 v2(69.07,74.99) ; DM1.228 89.08,44.5 v2(88.59,44.98)
M_A_DQ36: length 54.8
  L3 w0.089: v2(84.97,46.23) 84.63,46.23 83.77,47.09 83.77,48.75 83.86,48.83 84.06,48.83 84.15,48.92 84.15,49.11 84.06,49.2 83.86,49.2 83.77,49.29 83.77,49.48 83.86,49.57 84.06,49.57 84.15,49.66 84.15,49.85 84.06,49.94 83.86,49.94 83.77,50.03 83.77,50.22 83.86,50.31 84.06,50.31 84.15,50.4 84.15,50.59 84.06,50.68 83.86,50.68 83.77,50.76 83.77,52.28 66.86,69.2 66.86,76.71 67.31,77.17 67.31,78.15 v2(68.21,79.04)
  BOTTOM w0.076: CPU1.H36 72.97,84.45 72.52,83.63 72.52,83.57 72.14,83.19 72.12,83.19 71.86,82.93
  BOTTOM w0.089: 71.86,82.93 71.23,82.29 70.89,82.29
  BOTTOM w0.114: 70.89,82.29 70.16,82.29 68.81,80.95 68.81,79.43 68.43,79.04 v2(68.21,79.04) ; v2(84.97,46.23) 85.15,46.23 85.91,45.48 85.91,43.99 86.08,43.82 DM1.216
M_A_DQ37: length 55.8
  L3 w0.089: v2(68.02,77.14) 67.12,76.24 67.12,69.31 84.42,52.01 84.42,51.35 84.51,51.26 85.02,51.26 85.11,51.17 85.11,50.98 85.02,50.89 84.55,50.89 84.42,50.76 84.42,48.55 84.33,48.46 84.13,48.46 84.04,48.37 84.04,48.18 84.13,48.09 84.33,48.09 84.42,48 84.42,47.81 84.33,47.72 84.13,47.72 84.04,47.63 84.04,47.44 84.13,47.35 84.33,47.35 84.42,47.26 84.42,47 84.55,46.87 v2(84.98,46.87)
  BOTTOM w0.076: CPU1.H35 73.07,85.06 73.16,84.8 73.16,84.8 73.19,84.72 73.22,84.62 73.22,84.39 73.2,84.33 73.2,84.03 73.22,83.97 73.22,83.65 72.04,82.47
  BOTTOM w0.089: 72.04,82.47 71.38,81.81 70.63,81.81
  BOTTOM w0.114: DM1.215 85.83,50.1 85.71,49.99 85.71,47.61 v2(84.98,46.87) ; 70.63,81.81 69.45,80.64 69.45,79.3 69.12,78.97 69.12,78.23 v2(68.02,77.14)
M_A_DQ38: length 55.5
  L3 w0.089: v2(69.6,76.18) 69.21,76.18 68.66,75.62 68.66,74.42 68.75,74.33 69.16,74.33 69.26,74.23 69.26,74.05 69.17,73.97 68.7,73.97 68.61,73.88 68.61,73.69 68.7,73.6 69.03,73.6 69.12,73.51 69.12,69.4 88.6,49.92 88.6,46.39 88.51,46.31 88.26,46.31 88.17,46.22 88.17,46.04 88.26,45.95 88.51,45.95 88.6,45.86 88.6,45.59 88.11,45.1 v2(87.65,45.1)
  BOTTOM w0.076: CPU1.K36 74.27,84.45 74.4,84.21 74.4,84.2 74.53,83.97 74.53,82.8 73.71,81.98 73.55,81.98 73.33,81.76
  BOTTOM w0.114: v2(87.65,45.1) 88.08,44.68 DM1.224 ; 73.33,81.76 70.97,79.4 70.97,77.46 69.69,76.18 v2(69.6,76.18)
M_A_DQ39: length 54.7
  L3 w0.089: v2(87.94,47.31) 87.43,47.82 87.43,50.71 68.33,69.81 68.33,70.08 68.42,70.17 68.76,70.17 68.85,70.26 68.85,70.45 68.76,70.54 68.42,70.54 68.33,70.62 68.33,70.82 68.42,70.9 68.76,70.9 68.85,70.99 68.85,71.18 68.76,71.27 68.42,71.27 68.33,71.36 68.33,71.55 68.42,71.64 68.76,71.64 68.85,71.73 68.85,71.92 68.76,72.01 68.42,72.01 68.33,72.1 68.33,72.29 68.42,72.38 68.76,72.38 68.85,72.47 68.85,72.66 68.76,72.75 68.42,72.75 68.33,72.83 68.33,75.67 69.27,76.61 69.27,77.12 v2(69.64,77.5)
  BOTTOM w0.076: CPU1.K37 74.27,82.78 73.64,82.14 73.36,82.14
  BOTTOM w0.114: v2(87.94,47.31) 88.44,47.8 88.44,48.67 88.33,48.78 DM1.225 ; v2(69.64,77.5) 70.74,78.59 70.74,79.53 73.36,82.14
M_A_DQ40: length 56.3
  L3 w0.089: v2(71.68,78.56) 71.36,78.89 70.86,78.89 70.73,78.76 70.73,78.49 70.82,78.4 70.98,78.4 71.07,78.31 71.07,78.12 70.98,78.03 70.82,78.03 70.73,77.95 70.73,77.75 70.82,77.67 71.11,77.67 71.2,77.58 71.2,77.39 71.11,77.3 70.82,77.3 70.73,77.21 70.73,69.19 90.05,49.88 90.05,48.84 90.13,48.75 90.33,48.75 90.41,48.66 90.41,48.47 90.33,48.38 90.13,48.38 90.05,48.29 90.05,48.1 90.13,48.01 90.33,48.01 90.41,47.92 90.41,47.73 90.33,47.65 90.13,47.65 90.05,47.56 90.05,47.37 90.13,47.28 90.33,47.28 90.41,47.19 90.41,47 90.33,46.91 90.13,46.91 90.05,46.82 90.05,46.71 89.92,46.58 v2(89.59,46.58)
  BOTTOM w0.076: 73.76,81.27 73.77,81.27 75.16,82.66 75.16,83.84 75.33,84.17 75.33,84.2 75.49,84.48 CPU1.N36
  BOTTOM w0.114: v2(89.59,46.58) 91.09,45.08 91.09,44.04 91.08,44.02 DM1.236 ; 73.76,81.27 72.09,79.6 72.09,78.97 v2(71.68,78.56)
M_A_DQ41: length 55.9
  L3 w0.089: v2(91.74,47.3) 91.44,47.3 91.32,47.42 91.32,48.46 91.4,48.55 91.85,48.55 91.94,48.64 91.94,48.83 91.85,48.92 91.4,48.92 91.32,49.01 91.32,49.74 71.53,69.53 71.53,74.65 71.62,74.74 72.05,74.74 72.14,74.83 72.14,75.02 72.05,75.11 71.62,75.11 71.53,75.2 71.53,75.46 71.66,75.59 71.86,75.59 72.08,75.81 72.08,78.2 72.44,78.56 72.44,79.07 72.32,79.2 v2(71.64,79.2)
  BOTTOM w0.076: CPU1.N34 75.17,85.15 75.17,84.21 74.99,83.89 74.99,82.73 73.72,81.46 73.64,81.46
  BOTTOM w0.114: DM1.237 91.33,47.71 v2(91.74,47.3) ; v2(71.64,79.2) 71.64,79.46 73.64,81.46
M_A_DQ42: length 55.3
  L3 w0.089: v2(94.62,45.7) 93.96,45.7 93.83,45.83 93.83,46.11 93.92,46.2 94.18,46.2 94.27,46.28 94.27,46.44 94.16,46.55 93.92,46.55 93.83,46.64 93.83,48.91 72.75,69.99 72.75,73.53 73.99,74.78 73.99,77.75 74.08,77.84 74.23,77.84 74.32,77.93 74.32,78.1 74.23,78.19 74.08,78.19 73.99,78.28 73.99,78.46 74.08,78.55 74.23,78.55 74.32,78.64 74.32,78.82 74.23,78.9 74.08,78.9 73.99,78.99 73.99,79.17 74.08,79.26 74.23,79.26 74.32,79.35 74.32,79.53 74.23,79.62 74.08,79.62 73.99,79.7 73.99,80.09 74.12,80.21 v2(75.11,80.21)
  BOTTOM w0.089: 76.64,82.27 76.87,82.51 76.87,83.77 CPU1.R37
  BOTTOM w0.114: v2(94.62,45.7) 94.4,45.7 93.58,44.88 DM1.246 ; 76.64,82.27 76.16,81.79 76.16,81.26 v2(75.11,80.21)
M_A_DQ43: length 55.4
  L3 w0.089: v2(73.54,79.78) 73.69,79.63 73.69,74.96 72.48,73.75 72.48,69.88 93.56,48.81 93.56,44.25 93.68,44.12 94.47,44.12 v2(94.68,44.34)
  BOTTOM w0.076: CPU1.R34 76.07,85.81 75.86,85.6 75.86,84.78 75.91,84.65 75.91,84.36 75.88,84.3 75.88,84.06 75.91,84 75.91,83.5 75.66,83.25 75.66,82.26
  BOTTOM w0.114: 75.66,82.26 75.35,81.95 75.35,81.8 73.54,79.99 v2(73.54,79.78) ; v2(94.68,44.34) 94.69,44.33 94.69,44.15 94.58,44.03 DM1.250
M_A_DQ44: length 55.1
  L3 w0.089: v2(89.59,45.31) 90.07,44.83 90.68,44.83 90.81,44.96 90.81,45.15 90.72,45.24 90.35,45.24 90.26,45.33 90.26,45.52 90.35,45.61 90.72,45.61 90.81,45.7 90.81,45.89 90.72,45.98 90.18,45.98 90.09,46.06 90.09,46.25 90.18,46.34 90.59,46.34 90.68,46.43 90.68,49.62 71,69.3 71,76.86 71.43,77.29 v2(71.66,77.29)
  BOTTOM w0.076: 74.81,82.05 75.33,82.56 75.33,83.69 CPU1.N37
  BOTTOM w0.114: v2(71.66,77.29) 72.39,78.03 72.39,79.62 74.81,82.04 74.81,82.05 ; v2(89.59,45.31) 90.08,44.82 DM1.232
M_A_DQ45: length 55.7
  L3 w0.089: v2(91.8,46) 91.47,46 90.96,46.51 90.96,49.72 71.26,69.41 71.26,73.54 71.25,73.56 71.25,76.25 v2(71.66,76.66)
  BOTTOM w0.076: 75.15,82.03 75.49,82.37 75.49,83.36 75.74,83.61 75.74,83.97 75.72,84.03 75.72,84.33 75.74,84.39 75.74,84.61 75.67,84.82 75.67,84.97 CPU1.N35
  BOTTOM w0.114: v2(71.66,76.66) 71.66,76.65 71.94,76.66 72.77,77.49 72.77,79.66 75.15,82.03 ; v2(91.8,46) 90.41,47.39 90.41,49.86 90.33,49.95 DM1.233
M_A_DQ46: length 56
  L3 w0.089: v2(75.17,79.58) 74.7,79.58 74.58,79.45 74.58,74.64 74.49,74.55 74.29,74.55 74.2,74.46 74.2,74.29 74.29,74.2 74.49,74.2 74.58,74.11 74.58,73.84 74.39,73.65 74.26,73.65 73.85,74.06 73.7,74.06 73.59,73.94 73.59,73.82 74.01,73.39 74.01,73.27 73.89,73.14 73.76,73.14 73.4,73.5 73.28,73.5 73.15,73.38 73.15,73.25 73.51,72.89 73.51,72.77 73.02,72.27 73.02,70.11 94.34,48.78 94.34,47.45 94.47,47.33 v2(94.88,47.33)
  BOTTOM w0.076: 76.75,82.06 77.04,82.35 77.04,83.99 76.79,84.45 CPU1.R36
  BOTTOM w0.114: v2(94.88,47.33) 94.82,47.38 94.79,47.38 93.33,48.85 DM1.245 ; 76.75,82.06 76.41,81.71 76.41,80.82 v2(75.17,79.58)
M_A_DQ47: length 55.1
  L3 w0.089: v2(75.22,78.95) 74.86,78.59 74.86,75.98 74.95,75.89 75.5,75.89 75.59,75.8 75.59,75.63 75.5,75.54 74.95,75.54 74.86,75.45 74.86,75.27 74.95,75.18 75.5,75.18 75.59,75.09 75.59,74.92 75.5,74.83 74.95,74.83 74.86,74.74 74.86,74.56 74.95,74.47 75.5,74.47 75.59,74.38 75.59,74.2 75.5,74.11 74.95,74.11 74.86,74.03 74.86,73.85 74.95,73.76 75.38,73.76 75.49,73.65 75.49,73.49 75.4,73.4 74.52,73.4 73.28,72.16 73.28,70.22 v2(94.85,48.65)
  BOTTOM w0.076: CPU1.R35 76.79,84.91 77.08,84.62 77.08,84.26 77.22,84 77.22,83.32 77.25,83.29 77.25,82.25 77.14,82.14
  BOTTOM w0.114: DM1.249 94.33,49.04 94.71,48.65 v2(94.85,48.65) ; 77.14,82.14 76.66,81.66 76.66,80.39 v2(75.22,78.95)
M_A_DQ48: length 61.8
  L3 w0.089: v2(72.53,87.21) 72.03,86.7 72.03,86.5 71.78,86.25 70.28,86.25 67.73,83.69 66.99,83.69 63.18,79.88 62.65,79.35 62.65,65.04 73.46,54.23 73.59,54.23 73.87,54.51 73.99,54.51 74.12,54.38 74.12,54.26 73.84,53.98 73.84,53.85 73.97,53.72 74.09,53.72 74.37,54 74.5,54 74.62,53.88 74.62,53.75 74.34,53.47 74.34,53.35 74.47,53.22 74.59,53.22 74.88,53.5 75,53.5 75.13,53.38 75.13,53.25 74.85,52.97 74.85,52.84 74.97,52.72 75.1,52.72 75.38,53 75.5,53 75.63,52.87 75.63,52.75 75.35,52.47 75.35,52.34 75.48,52.22 75.6,52.22 75.88,52.5 76.01,52.5 76.13,52.37 76.13,52.24 75.85,51.96 75.85,51.84 75.98,51.71 76.1,51.71 76.33,51.94 76.46,51.94 76.58,51.82 76.58,51.69 76.35,51.46 76.35,51.34 77.7,49.99 77.7,47.7 v2(77.28,47.28)
  BOTTOM w0.114: v2(72.53,87.21) 72.27,87.47 72.13,87.47 72.1,87.5 CPU1.G31 ; v2(77.28,47.28) 77.73,47.73 77.73,48.13 77.71,48.15 77.71,49.78 77.83,49.89 DM1.183
M_A_DQ49: length 63.2
  L3 w0.089: v2(71.63,86.66) 70.08,86.66 68.79,85.37 68.25,85.37 62.38,79.51 62.38,64.88 63,64.26 63,64.14 62.75,63.89 62.75,63.77 62.88,63.64 63,63.64 63.25,63.89 63.37,63.89 63.5,63.76 63.5,63.63 63.26,63.39 63.26,63.27 63.38,63.14 63.51,63.14 63.75,63.38 63.88,63.38 64,63.26 64,63.13 63.76,62.89 63.76,62.76 63.88,62.64 64.01,62.64 64.25,62.88 64.38,62.88 64.5,62.75 64.5,62.63 64.26,62.39 64.26,62.26 64.39,62.13 64.51,62.13 64.76,62.38 64.88,62.38 65.01,62.25 65.01,62.13 64.76,61.88 64.76,61.76 64.89,61.63 65.02,61.63 65.26,61.87 65.38,61.87 65.51,61.75 65.51,61.62 65.27,61.38 65.27,61.25 65.39,61.13 65.52,61.13 65.76,61.37 65.89,61.37 66.01,61.25 66.01,61.12 65.77,60.88 65.77,60.75 65.9,60.63 66.02,60.63 66.26,60.87 66.39,60.87 66.52,60.74 66.52,60.62 66.27,60.37 66.27,60.25 66.4,60.12 66.52,60.12 66.77,60.37 66.89,60.37 67.02,60.24 67.02,60.11 66.78,59.87 66.78,59.75 66.9,59.62 67.03,59.62 67.27,59.86 67.4,59.86 76.55,50.71 76.55,47.64 76.56,47.63 76.56,47.46 76.86,47.16 76.86,45.02 77.48,44.4 v2(77.59,44.4)
  BOTTOM w0.114: DM1.182 77.58,44.38 v2(77.59,44.4) ; CPU1.G32 71.81,86.85 v2(71.63,86.66)
M_A_DQ50: length 62.8
  L3 w0.089: v2(74.81,47.73) 74.28,47.73 73.96,48.05 73.96,50.6 73.66,50.9 73.66,51.02 74.01,51.37 74.01,51.5 73.88,51.63 73.76,51.63 73.41,51.28 73.28,51.28 73.15,51.4 73.15,51.53 73.5,51.88 73.5,52 73.38,52.13 73.25,52.13 72.9,51.78 72.78,51.78 61.19,63.37 61.19,80.72 63.5,83.03 63.5,87.31 64.33,88.13 70.64,88.13 71.51,89 72.38,89 v2(72.54,89.16)
  BOTTOM w0.114: v2(72.54,89.16) 72.65,89.16 CPU1.H29 ; DM1.169 74.33,48.2 74.79,47.73 v2(74.81,47.73)
M_A_DQ51: length 62.7
  L3 w0.089: v2(72.57,89.79) 71.78,89.2 71.16,89.2 71.08,89.28 70.18,89.28 68.28,88.4 64.44,88.4 64.22,88.4 63.24,87.42 63.24,83.22 60.92,80.91 60.92,63.26 73.69,50.49 73.69,47.94 74.23,47.4 74.23,46.7 74.97,45.96 v2(76.03,44.98)
  BOTTOM w0.114: v2(72.57,89.79) 72.67,89.79 CPU1.H28 ; v2(76.03,44.98) 75.58,44.53 DM1.174
M_A_DQ52: length 61.5
  L3 w0.089: v2(74.58,44.56) 74.24,44.85 74.06,45.02 73.91,45.15 73.91,47.34 72.75,48.5 72.75,51.05 60.65,63.15 60.65,81.12 62.97,83.44 62.97,87.53 64.18,88.73 66.83,88.73 67.08,88.98 67.08,89.14 67.38,89.44 70.08,89.6 v2(71.6,89.6)
  BOTTOM w0.114: DM1.170 v2(74.58,44.56) ; v2(71.6,89.6) 71.62,89.6 71.78,89.45 CPU1.G28
M_A_DQ53: length 63.1
  L3 w0.089: v2(74.83,49.02) 74.53,49.02 74.4,49.15 74.4,51.48 73.17,52.71 73.04,52.71 72.7,52.36 72.57,52.36 72.44,52.49 72.44,52.62 72.79,52.97 72.79,53.09 72.67,53.22 72.54,53.22 72.19,52.87 72.07,52.87 71.94,52.99 71.94,53.12 72.29,53.47 72.29,53.59 72.16,53.72 72.04,53.72 71.69,53.37 71.56,53.37 71.44,53.5 71.44,53.62 71.79,53.97 71.79,54.1 71.66,54.22 71.54,54.22 71.19,53.87 71.06,53.87 70.94,54 70.94,54.13 71.28,54.47 71.28,54.6 71.16,54.73 71.03,54.73 70.68,54.38 70.56,54.38 70.43,54.5 70.43,54.63 70.78,54.98 70.78,55.1 70.66,55.23 70.53,55.23 70.18,54.88 70.06,54.88 69.93,55.01 69.93,55.13 70.28,55.48 70.28,55.61 70.15,55.73 70.03,55.73 69.68,55.38 69.55,55.38 61.45,63.48 61.45,80.45 63.77,82.77 63.77,86 64.82,87.05 68.86,87.05 69.55,87.73 70.81,87.73 v2(71.64,88.56)
  BOTTOM w0.114: v2(74.83,49.02) 74.88,49.07 74.89,49.07 75.33,49.51 DM1.173 ; v2(71.64,88.56) 71.64,88.57 71.87,88.57 CPU1.G29
M_A_DQ54: length 62.7
  L3 w0.089: v2(79.07,44.97) 78.18,45.86 78.18,50.73 73.66,55.25 73.53,55.25 73.24,54.95 73.11,54.95 72.99,55.08 72.99,55.21 73.28,55.5 73.28,55.63 73.16,55.75 73.03,55.75 72.74,55.46 72.61,55.46 72.49,55.58 72.49,55.71 72.78,56 72.78,56.13 72.65,56.25 72.53,56.25 72.23,55.96 72.11,55.96 71.98,56.09 71.98,56.21 72.28,56.51 72.28,56.63 72.15,56.76 72.03,56.76 71.73,56.46 71.61,56.46 71.48,56.59 71.48,56.71 71.77,57.01 71.77,57.13 71.65,57.26 71.52,57.26 71.23,56.97 71.1,56.97 62.91,65.15 62.91,79.24 63.29,79.61 67.15,83.48 67.96,83.48 70.52,86.04 71.93,86.04 72.93,87.04 72.93,87.34 v2(73.41,87.82)
  BOTTOM w0.114: CPU1.H31 73.06,87.5 73.37,87.82 v2(73.41,87.82) ; DM1.186 78.58,44.47 v2(79.07,44.97)
M_A_DQ55: length 63.9
  L3 w0.089: v2(72.86,86.36) 72.62,86.36 72.01,85.74 72.01,85.61 70.63,84.23 69.04,84.23 68.08,83.26 67.31,83.26 63.4,79.35 63.18,79.13 63.18,65.26 66.39,62.06 66.51,62.06 66.83,62.38 66.96,62.38 67.09,62.26 67.09,62.13 66.76,61.81 66.76,61.68 66.89,61.56 67.02,61.56 67.34,61.88 67.46,61.88 67.59,61.75 67.59,61.63 67.27,61.3 67.27,61.18 67.39,61.05 67.52,61.05 67.84,61.38 67.97,61.38 68.09,61.25 68.09,61.12 67.77,60.8 67.77,60.68 67.9,60.55 68.02,60.55 68.34,60.87 68.47,60.87 68.59,60.75 68.59,60.62 68.27,60.3 68.27,60.17 68.4,60.05 68.52,60.05 68.85,60.37 68.97,60.37 69.1,60.24 69.1,60.12 68.78,59.8 68.78,59.67 68.9,59.54 69.03,59.54 69.35,59.87 69.47,59.87 69.6,59.74 69.6,59.62 69.28,59.29 69.28,59.17 69.4,59.04 69.53,59.04 69.85,59.36 69.98,59.36 70.1,59.24 70.1,59.11 69.78,58.79 69.78,58.66 69.91,58.54 70.03,58.54 70.35,58.86 70.48,58.86 70.61,58.73 70.61,58.61 70.28,58.29 70.28,58.16 70.41,58.04 70.54,58.04 70.86,58.36 70.98,58.36 71.11,58.23 71.11,58.11 70.79,57.78 70.79,57.66 70.91,57.53 71.04,57.53 71.36,57.86 71.49,57.86 78.66,50.68 v2(78.66,48.23)
  BOTTOM w0.114: v2(78.66,48.23) 78.71,48.28 78.71,49.57 78.83,49.68 DM1.187 ; CPU1.H32 72.9,86.39 v2(72.86,86.36)
M_A_DQ56: length 64.1
  L3 w0.089: v2(80.39,47.57) 80.55,47.73 80.55,47.99 80.46,48.08 79.86,48.08 79.77,48.17 79.77,48.35 79.86,48.44 80.46,48.44 80.55,48.53 80.55,49.55 80.46,49.64 80.18,49.64 80.09,49.73 80.09,49.9 80.18,49.99 80.46,49.99 80.55,50.08 80.55,50.52 66.75,64.31 66.75,64.44 67.05,64.74 67.05,64.86 66.92,64.99 66.8,64.99 66.5,64.69 66.38,64.69 66.25,64.82 66.25,64.94 66.55,65.24 66.55,65.36 66.42,65.49 66.3,65.49 66,65.19 65.87,65.19 65.75,65.32 65.75,65.45 66.04,65.74 66.04,65.87 65.92,65.99 65.79,65.99 65.5,65.7 65.37,65.7 65.25,65.82 65.25,65.95 65.54,66.24 65.54,66.37 65.42,66.5 65.29,66.5 64.99,66.2 64.87,66.2 64.74,66.33 64.74,66.45 65.04,66.75 65.04,66.87 64.91,67 64.79,67 64.49,66.7 64.37,66.7 64.18,66.89 64.18,78.4 65.08,79.3 65.08,80.1 67.59,82.61 71.25,82.61 73.75,85.12 73.75,86.55 73.99,86.8 74.04,86.8 v2(74.42,87.18)
  BOTTOM w0.114: CPU1.L31 v2(74.42,87.18) ; DM1.195 80.83,47.98 80.41,47.57 v2(80.39,47.57)
