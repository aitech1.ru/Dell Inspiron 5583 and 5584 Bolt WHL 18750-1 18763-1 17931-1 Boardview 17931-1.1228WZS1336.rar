# Allegro board 17931-1.1228WZS1336.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPU_THM_SMBDAT: length 384.7
  TOP w0.114: R2455.2 214.51,55.53 214.37,55.67 214.37,57.78 212.41,59.73 212.41,60.06 210.75,61.72 210.75,63.12 210.42,63.45 208.92,63.45 v2(208.38,62.92) 207.7,62.23 v1(207.55,62.23) 207.05,62.23 207.01,62.19 204.6,62.19 203.2,63.59 200.36,63.59 199.94,64.01 R2447.2 ; v2(33.15,102.9) 32.69,102.9 32.52,102.72 32.52,101.32 32.81,101.03 Q5801.6 ; v2(21.34,66.22) 21.34,67.29 22.47,68.42 22.98,68.42 23.05,68.49 U2401.11
  L3 w0.089: v2(208.38,62.92) 209.02,62.28 210.62,62.28 213.56,59.34 214.26,59.34 218.73,54.86 218.73,38.92 218.08,38.27 217.11,38.27 217.11,38.27 216.51,38.27 216.12,37.88 216.11,37.88 215.55,37.32 212.9,37.32 212.39,37.82 209.39,37.82 205.89,34.33 200.35,34.33 197.84,31.81 190.09,31.81 189.36,32.55 175.57,32.55 173.37,34.75 168.8,34.75 167.73,35.82 166.69,35.82 166.68,35.82 166.53,35.82 165.79,35.09 150.85,35.09 149.65,33.89 145.23,33.89 144.5,33.15 141.02,33.15 v2(140.59,33.58)
  L6 w0.114: v2(140.59,33.58) 141.03,34.02 141.04,34.02 142.05,35.03 142.05,35.46 141.66,35.85 140.02,35.85 138,37.87 129.49,37.87 128.88,38.48 128.04,38.48 123.88,42.65 112.75,42.65 111.03,40.92 111.03,37.03 108.33,34.34 107.42,34.34 104.35,31.27 90.73,31.27 89.13,29.67 41.35,29.67 37.14,25.45 22.94,25.45 20.91,27.48 20.91,35.61 20.63,35.89 20.63,38.84 19.31,40.16 19.31,58.83 21.4,60.92 22.09,60.92 22.82,61.66 22.82,63.36 21.64,64.54 21.64,65.91 v2(21.34,66.22) 21.34,66.52 25.95,71.14 28.3,71.14 29.76,72.6 34.36,72.6 36.08,70.88 38.24,70.88 40.73,73.36 40.73,74.48 41.51,75.27 42.3,75.27 42.89,75.86 42.89,80.68 44.33,82.12 44.33,84.89 43.07,86.14 43.07,92.88 41.24,94.7 37.79,94.7 37.37,95.13 37.37,97.36 34.01,100.71 34.01,102.03 v2(33.15,102.9)
GSENSOR_CS: length 3.2
  TOP w0.254: R7006.1 133.12,94.38 132.95,94.56 v2(132.56,94.72) 132.49,94.72 v1(131.94,94.17)
  BOTTOM w0.254: v2(132.56,94.72) 132.64,94.72 133.06,94.3 U7001.2
GSENSOR_SDO: length 2.4
  TOP w0.089: R7007.2 132.67,95.51 v2(132.56,95.39) v1(131.91,95.39)
  BOTTOM w0.089: v2(132.56,95.39) 133.14,94.8 U7001.3
H_CPUPWRGD: length 10.6
  BOTTOM w0.089: R1714.1 89.15,114.63 ED301.2 89.24,114.68 89.88,114.04 v1(89.88,113.16) 89.88,110.19 89.79,110.1 89.79,109.56 89.88,109.48 89.88,106.25 CPU1.AR2
H_PECI: length 3
  TOP w0.114: R2437.1 C2405.1 40.49,72.04 v1(40.26,71.81) 40.15,71.69 U2401.94
HDA_BITCLK_CODEC: length 144.7
  TOP w0.114: ER2701.1 26.85,20.45 26.65,20.65 EC1901.2 26.53,21.02 25.61,21.95 25.43,21.95 EC2706.1 24.82,22.56 24.82,23.55 25.25,23.98 25.25,25.68 25.12,25.81 24.54,25.81 24.41,25.93 24.41,26.15 24.59,26.33 24.93,26.33 25.05,26.46 25.05,27.29 24.93,27.4 24.69,27.4 24.58,27.52 24.58,27.75 24.69,27.86 24.95,27.86 25.05,27.96 25.05,28.42 25.06,28.44 25.06,28.46 26.33,29.73 26.33,33.19 v1(26.34,33.2) 26.34,33.72 26.34,33.73 26.34,34.37 28.51,36.55 28.51,37.98 31.38,40.84 34.42,40.84 35.03,41.45 35.03,42.25 36.29,43.52 37.46,43.52 40.76,43.52 41.51,44.26 41.51,46.24 41.96,46.69 42.77,46.69 43.21,46.26 44.83,46.26 45.14,46.57 45.14,49.98 46.43,51.28 47.24,52.08 47.24,52.08 54.3,59.15 100.42,59.15 100.8,58.76 106.72,58.76 v2(115.95,68)
  BOTTOM w0.114: R1920.1 103.53,77.23 113.22,67.54 115.5,67.54 v2(115.95,68)
HDA_BITCLK_CODEC_R: length 3.8
  TOP w0.114: HDA27.5 27.13,16.57 27.03,16.67 27.03,17.12 26.85,17.3 ER2701.2 27.21,19.18 27.59,19.18 v1(27.77,19.36)
HDA_BITCLK_CPU: length 6.4
  BOTTOM w0.114: R1920.2 103.62,79.34 v1(103.62,80.13) 103.32,80.42 102.48,80.42 100.66,82.24 CPU1.BN37
HDA_CODEC_SDIN0: length 5.5
  TOP w0.114: HDA27.7 26.33,16.78 25.23,17.88 25.23,18.85 R2724.2 24.59,19.2 24.36,19.43 24.36,20.44 v1(24.12,20.68)
HDA_RST_N_CPU: length 3.9
  BOTTOM w0.114: TP1901.1 99.78,81.74 99.78,84.71 99.44,85.04 CPU1.BL35
HDA_SDIN0_CPU: length 154.8
  TOP w0.114: v2(117.2,66.93) 107.99,57.72 99.4,57.72 99.14,57.98 54.99,57.98 46.14,49.13 46.14,44.35 44.97,43.17 42.02,43.17 41.36,42.51 37.04,42.51 36.09,41.56 36.09,39.59 34.94,38.44 34.94,38.06 33.75,36.87 31.82,36.87 29.41,34.46 29.41,32.23 v1(29.18,32) 28.77,31.59 28.77,29.85 27.13,28.21 27.13,23.4 27.07,23.35 27.07,22.51 v2(27.18,22.4) ; R2724.1 24.87,20.37 v2(25.2,20.7)
  BOTTOM w0.076: 100.13,83.38 100.13,83.95 100.28,84.1 100.3,84.15 100.3,84.8 CPU1.BN35
  BOTTOM w0.114: v2(117.2,66.93) 117.09,66.82 117.09,66.57 116.61,66.09 112.69,66.09 101.45,77.33 101.45,79.96 100.64,80.77 100.64,81.61 100.13,82.12 100.13,83.38 ; v2(27.18,22.4) 27.18,22.81 26.47,23.52 25.03,23.52 24.9,23.39 24.9,22.86 24.95,22.81 24.95,20.96 v2(25.2,20.7)
HDA_SDOUT_CODEC: length 144.7
  TOP w0.114: HDA27.4 27.53,16.51 27.35,16.68 27.35,18.7 27.46,18.8 27.79,18.8 28.13,19.14 28.13,19.51 27.41,20.22 EC1903.1 27.41,20.97 26.73,21.65 26.73,23.49 26.79,23.55 26.79,28.35 28.43,29.99 28.43,32.37 29.07,33 29.07,34.65 v1(30.84,36.42) 31.63,37.21 33.61,37.21 34.6,38.2 34.6,38.58 35.75,39.74 35.75,41.7 36.9,42.86 41.22,42.86 41.88,43.52 44.83,43.52 45.8,44.49 45.8,49.27 54.85,58.32 99.29,58.32 99.54,58.07 107.01,58.07 115.86,66.91 v2(116.28,66.91)
  BOTTOM w0.114: R1921.1 102.67,77.15 112.99,66.83 116.2,66.83 v2(116.28,66.91)
HDA_SDOUT_CPU: length 6.7
  BOTTOM w0.076: 100.41,83.36 100.4,83.37 100.4,83.99 100.41,84 100.45,84.06 100.66,84.27 CPU1.BN36
  BOTTOM w0.114: R1921.2 R1512.2 101.88,79.27 R1909.2 101.88,80.14 v1(101.19,80.83) 101.12,80.9 101.12,81.43 100.41,82.15 100.41,83.36
HDA_SPKR_R: length 2.9
  TOP w0.127: D2703.1 23.84,23.64 24.39,24.18 24.39,24.28 24.51,24.41 v1(24.53,24.41) 24.53,24.49 23.96,25.07 R2740.2
HDA_SYNC_CODEC: length 147.9
  TOP w0.114: v2(115.29,68) 115.14,68 106.25,59.11 101.27,59.11 100.89,59.49 54.44,59.49 54.16,59.49 47.09,52.43 44.78,50.11 44.78,46.95 44.44,46.6 43.35,46.6 42.91,47.04 41.82,47.04 41.15,46.37 41.15,44.39 40.62,43.86 37.6,43.86 37.6,43.86 36.44,43.86 36.15,43.86 34.69,42.39 34.69,41.59 34.28,41.19 31.24,41.19 28.17,38.12 28.17,36.69 25.98,34.5 25.98,29.86 v1(24.24,28.12) 24.24,27.02 23.52,26.31 22.76,26.31 22.56,26.11 22.56,24.75 21.87,24.06 21.87,23.69 21.4,23.22 21.4,22.59 22.37,21.62 23.27,21.62 23.75,21.13 23.75,20.53 23.93,20.36 23.93,19.06 23.68,18.81 23.68,17.49 23.95,17.22 23.97,17.22 24.47,16.71 25.38,16.71 25.53,16.57 HDA27.9
  BOTTOM w0.114: R1908.1 104.29,76.95 113.24,68 v2(115.29,68)
HDA_SYNC_CPU: length 8.7
  BOTTOM w0.114: R1908.2 104.29,79.99 103.65,80.63 102.59,80.63 102.24,80.98 v1(102.24,81.46) 101,82.69 101,85.46 CPU1.BN34
HDD2_SATA_RX_CON_N: length 2.9
  TOP w0.114: C6030.2 163.44,39.51 163.44,40.02 v2(163.71,40.29)
  BOTTOM w0.114: v2(163.71,40.29) 163.46,40.04 163.46,39.73 163.65,39.55 HDD2.5
HDD2_SATA_RX_CON_P: length 3.8
  TOP w0.114: v1(162.06,38.84) 162.46,39.24 C6031.2 163.21,39.51 163.21,40.14 v2(163.07,40.29)
  BOTTOM w0.114: HDD2.6 163.15,39.55 163.23,39.63 163.23,40.12 v2(163.07,40.29)
HDD2_SATA_TX_CON_N: length 2.8
  TOP w0.114: C6029.2 164.78,39.43 164.78,40.1 v2(164.6,40.29)
  BOTTOM w0.114: HDD2.3 164.65,39.55 164.79,39.68 164.79,40.09 v2(164.6,40.29)
HDD2_SATA_TX_CON_P: length 3.7
  TOP w0.114: v2(165.23,40.29) 165.01,40.07 165.01,39.59 C6028.2 v1(166.25,39.24)
  BOTTOM w0.114: v2(165.23,40.29) 165.01,40.07 165.01,39.68 165.15,39.55 HDD2.2
HDD_DET#: length 128.7
  TOP w0.089: v2(154.26,40.21) 154.42,40.05 154.42,40.03 154.59,39.86 R2047.2 ; v1(108.25,93.49) 108.63,93.87 v2(108.63,93.91)
  L5 w0.089: v2(157.71,58.14) 159.46,59.89 166.86,59.89 168.64,58.1 168.64,54.68 170.59,52.73 170.59,44.58 170.59,43.95 169.77,43.14 168.78,43.14 168.78,43.14 168.73,43.14 168.73,43.13 168.39,43.13 168.1,43.13 165.74,43.14 v2(164.24,41.63)
  L6 w0.089: v2(108.63,93.91) 108.21,93.48 108.21,92.41 108.38,92.23 108.89,92.23 109.18,91.94 109.18,91.41 108.57,90.8 108.57,90.53 107.65,89.61 107.65,86.13 109.25,84.53 109.25,79.5 118.27,70.49 118.27,68.96 129.1,58.13 154.93,58.13 155.43,58.62 157.33,58.62 157.53,58.42 157.53,58.32 v2(157.71,58.14) ; v2(154.26,40.21) 155.68,41.63 v2(164.24,41.63)
  BOTTOM w0.089: v2(108.63,93.91) 109.01,94.28 CPU1.CG20 ; v2(154.26,40.21) 154.42,40.05 154.42,40.03 154.67,39.78 155.91,39.78 156.49,40.36 158.42,40.36 158.65,40.13 HDD1.6
HDD_DEVSLP: length 132.9
  TOP w0.089: v2(153.62,40.21) 153.83,40.01 R6002.1
  L6 w0.089: v2(115.9,101.31) 115.97,101.31 117.83,103.17 118.77,103.17 119.54,102.4 119.54,99.22 119.19,98.86 119.19,95.27 119.46,95 119.46,90.43 119.72,90.16 119.72,89.03 118.97,88.29 118.97,86.72 117.19,84.93 117.19,75.11 117.58,74.72 117.58,74.72 124.86,67.44 127.33,67.44 131,63.78 161.83,63.78 162.36,63.25 167.36,63.25 170.59,60.02 170.59,59.39 171.54,58.43 171.54,55.21 171.12,54.79 171.12,43.83 169.58,42.29 155.71,42.29 v2(153.62,40.21)
  BOTTOM w0.076: v1(115.47,101.73) 115.38,101.82 113.45,101.82 113.28,101.91 113.08,101.91 CPU1.CP8
  BOTTOM w0.089: v2(115.9,101.31) 115.48,101.73 v1(115.47,101.73)
HDD_DEVSLP_R: length 10.7
  TOP w0.089: R6002.2 v1(153.83,37.77) 154.26,37.77 v2(154.74,38.25)
  BOTTOM w0.089: HDD1.13 162.15,37.89 161.88,37.62 155.37,37.62 v2(154.74,38.25)
HDD_SATA_RX_N11: length 161.5
  TOP w0.114: 163.33,34.47 163.33,34.83 163.57,35.07 163.57,35.3 163.69,35.42 ED6001.7 ED6001.4 163.69,37.03 163.57,37.16 163.57,37.42 163.44,37.55 163.44,38.06 C6030.1 ; 163.33,34.47 v1(163.48,34.47) ; 163.33,34.47 163.33,34.04 v2(163.55,33.81)
  L6 w0.102: v2(100.88,101.43) 100.88,101.51 100.64,101.75 100.51,101.75 100.38,101.63 100.38,100.49 101.14,99.73 106.67,99.73 107,99.41 107.36,99.41 107.61,99.65 111.88,99.65 114.22,101.99 115.84,101.99 117.67,103.82 119.3,103.82 121.01,102.11 121.04,102.11 121.42,101.74 121.42,100.52 120.48,99.58 120.48,99.06 119.94,98.53 119.94,96.95 120.27,96.62 120.27,90.7 121.24,89.74 121.24,89.21 122.52,87.93 122.52,82.81 119.38,79.67 119.38,74.37 125.38,68.38 127.8,68.38 130.49,65.69 154.52,65.69 155.51,64.7 164.16,64.7 164.8,64.06 168.86,64.06 169.34,63.58 171.1,63.58 171.56,64.03 173.34,64.03 173.89,63.48 173.89,61.12 174.78,60.23 174.78,57.51 176.3,55.98 176.3,46.08 176.03,45.8 176.03,40.8 171.05,35.82 168.67,35.82 168.41,35.56 166.46,35.56 166.06,35.16 163.97,35.16 163.33,34.52 163.33,34.04 v2(163.55,33.81)
  BOTTOM w0.114: CPU1.BN10 100.48,101.03 v2(100.88,101.43)
HDD_SATA_RX_P11: length 161.6
  TOP w0.114: 163.21,37.54 163.21,38.06 C6031.1 ; 163.21,37.54 163.21,37.45 163.33,37.33 163.33,37.15 163.21,37.03 ED6001.5 ED6001.6 163.21,35.44 163.34,35.32 163.34,35.17 163.1,34.93 163.1,33.99 v2(162.92,33.81) ; 163.21,37.54 v1(163.07,37.54)
  L6 w0.102: v2(100.92,102.11) 100.76,101.96 100.43,101.96 100.18,101.71 100.18,100.41 101.06,99.53 106.59,99.53 106.91,99.2 107.45,99.2 107.69,99.45 111.96,99.45 114.31,101.79 115.93,101.79 117.75,103.62 119.21,103.62 120.92,101.91 120.96,101.91 121.21,101.65 121.21,100.6 120.27,99.66 120.27,99.15 119.74,98.61 119.74,96.87 120.07,96.54 120.07,90.62 121.03,89.66 121.03,89.12 122.32,87.84 122.32,82.89 119.18,79.76 119.18,74.29 125.29,68.17 127.71,68.17 130.41,65.48 154.44,65.48 155.43,64.49 164.08,64.49 164.71,63.86 168.77,63.86 169.25,63.37 171.19,63.37 171.64,63.83 173.26,63.83 173.69,63.4 173.69,61.03 174.58,60.14 174.58,57.42 176.1,55.9 176.1,46.16 175.82,45.88 175.82,40.88 170.96,36.02 168.59,36.02 168.33,35.76 166.37,35.76 165.97,35.36 163.88,35.36 163.12,34.61 163.12,34.01 v2(162.92,33.81)
  BOTTOM w0.114: v2(100.92,102.11) 100.91,102.1 100.74,102.1 CPU1.BN8
HDD_SATA_TX_N11: length 171.1
  TOP w0.114: v2(164.82,33.81) 165,33.99 165,34.27 164.86,34.41 164.86,34.62 ; C6029.1 164.86,38.06 164.86,37.16 164.73,37.03 ED6001.2 ED6001.9 164.73,35.35 164.86,35.22 164.86,34.62 ; 164.86,34.62 v1(164.7,34.62)
  L6 w0.076: 102.19,100.12 102.17,100.12 102.16,100.13 101.83,100.13 101.43,100.53 101.43,100.95 101.32,101.05 101.32,103.68 101.03,103.97 101.03,104.82 101.84,105.63 101.84,108.53 101.6,108.77 101.19,108.77 v2(101.02,108.6)
  L6 w0.102: v2(164.82,33.81) 165.04,34.03 165.04,34.29 165.29,34.53 167.88,34.53 168.14,34.79 170.94,34.79 176.51,40.35 176.51,45.74 176.69,45.92 176.69,55.88 176.81,56.01 176.81,57.17 175.21,58.77 175.21,60.33 174.27,61.27 174.27,63.92 173.78,64.42 171.4,64.42 170.95,63.96 169.51,63.96 168.3,65.18 155.68,65.18 154.79,66.07 130.66,66.07 127.97,68.76 125.67,68.76 119.89,74.54 119.89,79.61 122.91,82.63 122.91,89.65 121.39,91.17 121.39,96.82 120.86,97.35 120.86,99.42 121.8,100.36 121.8,101.92 119.44,104.27 117.55,104.27 115.77,102.49 113.74,102.49 111.96,100.71 107.57,100.71 107.13,100.27 107,100.27 106.85,100.12 102.19,100.12
  BOTTOM w0.076: CPU1.BN4 100.64,104.83 100.64,105.37 100.76,105.66 100.76,105.66 100.78,105.67 100.78,105.97 100.75,106.05 100.75,106.27 100.77,106.32 100.78,106.35 100.78,106.74 100.58,106.94 100.58,108.71 100.67,108.8 100.82,108.8 v2(101.02,108.6)
HDD_SATA_TX_P11: length 171
  TOP w0.114: 165.09,37.54 165.09,37.16 165.21,37.03 ED6001.1 ED6001.10 165.21,35.34 165.09,35.22 165.09,34.5 165.23,34.36 165.23,34.04 v2(165.46,33.81) ; 165.09,37.54 v1(165.23,37.54) ; 165.09,37.54 165.09,38.06 C6028.1
  L6 w0.076: 102.19,100.32 102.17,100.32 102.16,100.31 101.91,100.31 101.6,100.61 101.6,101.02 101.5,101.12 101.5,103.75 101.21,104.04 101.21,104.74 102.02,105.56 102.02,108.61 101.68,108.95 101.3,108.95 v2(101.01,109.23)
  L6 w0.102: v2(165.46,33.81) 165.24,34.02 165.24,34.2 165.37,34.33 167.97,34.33 168.22,34.58 171.02,34.58 176.71,40.27 176.71,45.66 176.89,45.84 176.89,55.8 177.02,55.92 177.02,57.26 175.42,58.86 175.42,60.42 174.48,61.36 174.48,64.01 173.86,64.62 171.32,64.62 170.86,64.16 169.6,64.16 168.38,65.38 155.76,65.38 154.87,66.27 130.74,66.27 128.05,68.96 125.76,68.96 120.09,74.63 120.09,79.52 123.12,82.54 123.12,89.73 121.59,91.25 121.59,96.9 121.06,97.44 121.06,99.34 122,100.28 122,102.01 119.53,104.48 117.46,104.48 115.68,102.7 113.65,102.7 111.87,100.92 107.49,100.92 107.04,100.47 106.91,100.47 106.76,100.32 102.19,100.32
  BOTTOM w0.076: v2(101.01,109.23) 100.76,108.98 100.6,108.98 100.4,108.78 100.4,106.87 100.6,106.67 100.6,106.38 100.57,106.3 100.57,106.02 100.6,105.94 100.6,105.73 100.36,105.18 CPU1.BN3
HDMI_DDI_TX_CMC_N0: length 5.1
  BOTTOM w0.114: 21.69,98.78 21.44,98.78 20.96,98.3 20.96,97.99 20.84,97.88 20.67,97.88 20.5,98.04 EL5703.1 ; 21.69,98.78 22.28,98.78 R5775.1 22.87,98.8 23.8,98.8 C5781.2 ; 21.69,98.78 v1(21.69,98.93)
HDMI_DDI_TX_CMC_N1: length 3.8
  BOTTOM w0.114: EL5702.1 20.35,96.49 20.51,96.34 20.85,96.34 21.01,96.5 21.42,96.5 R5773.1 22.05,96.62 22.06,96.62 22.46,96.62 22.67,96.83 23.07,96.83 C5779.2
HDMI_DDI_TX_CMC_N2: length 4.4
  BOTTOM w0.114: EL5701.1 20.4,94.94 20.56,94.78 21.22,94.78 21.62,94.39 22.3,94.39 R5705.1 22.71,94.59 23.5,94.59 C5777.2
HDMI_DDI_TX_CMC_N3: length 6.5
  BOTTOM w0.114: C5783.2 24.51,101.02 23.57,101.02 R5777.1 23.14,100.94 22.13,100.94 C5724.2 21.4,100.87 21.25,100.87 21,100.63 21,100.33 ; 21,100.33 21,99.66 20.79,99.45 20.61,99.45 20.45,99.62 EL5704.1 ; 21,100.33 v1(20.86,100.33)
HDMI_DDI_TX_CMC_P0: length 4.9
  BOTTOM w0.114: EL5703.2 20.53,97.49 20.69,97.65 20.94,97.65 21.19,97.9 21.19,98.2 21.54,98.55 22.28,98.55 R5776.1 22.63,98.25 22.96,98.58 23.86,98.58 C5782.2
HDMI_DDI_TX_CMC_P1: length 3.8
  BOTTOM w0.114: EL5702.2 20.35,95.94 20.52,96.11 20.95,96.11 21.1,96.27 21.57,96.27 R5774.1 22.15,96.39 22.56,96.39 22.76,96.6 23.07,96.6 C5780.2
HDMI_DDI_TX_CMC_P2: length 4.6
  BOTTOM w0.114: EL5701.2 20.4,94.39 20.56,94.55 21.13,94.55 21.52,94.16 21.64,94.16 ; 21.64,94.16 22.3,94.16 R5759.1 23.12,94.36 23.85,94.36 C5778.2 ; 21.64,94.16 v1(21.64,94.03)
HDMI_DDI_TX_CMC_P3: length 6.4
  BOTTOM w0.114: EL5704.2 20.48,99.07 20.64,99.23 20.89,99.23 21.23,99.57 21.23,100.53 21.35,100.65 21.51,100.65 C5724.1 22.15,100.71 23.17,100.71 R5778.1 23.7,100.79 24.36,100.79 C5784.2
HDMI_DDI_TX_CON_N0: length 17.7
  TOP w0.114: v2(13.6,98.87) 13.59,98.88 v1(13.59,99.44)
  L3 w0.089: HDMI1.9 10.4,98.45 10.71,98.45 10.91,98.24 10.91,94.91 11.28,94.54 12.07,94.54 12.78,95.25 12.78,98.26 13.1,98.57 13.3,98.57 v2(13.6,98.87)
  BOTTOM w0.114: EL5703.4 18.72,98.04 18.56,97.88 18.27,97.88 18.09,98.06 17.72,98.06 17.59,98.18 ED5702.4 ED5702.7 15.41,98.18 15.05,98.54 ER5703.2 14.75,98.25 14.52,98.25 14.25,98.53 13.95,98.53 v2(13.6,98.87)
HDMI_DDI_TX_CON_N1: length 8.3
  BOTTOM w0.114: HDMI1.6 11.94,96.96 13.3,96.96 13.81,96.46 14.66,96.46 ER5702.2 15.37,96.53 15.76,96.53 15.88,96.66 ED5701.5 ED5701.6 17.7,96.66 17.87,96.49 EL5702.4
HDMI_DDI_TX_CON_N2: length 10.3
  BOTTOM w0.114: EL5701.4 18.56,94.94 18.44,94.82 18.29,94.82 18.1,95.01 17.72,95.01 17.59,95.14 ED5701.9 ED5701.2 15.92,95.14 15.8,95.01 15.63,95.01 15.5,94.88 15.32,94.88 ER5701.2 14.72,94.82 13.47,94.82 13.08,94.44 11.56,94.44 10.62,95.38 10.47,95.38 HDMI1.3
HDMI_DDI_TX_CON_N3: length 8.2
  BOTTOM w0.114: EL5704.4 18.69,99.62 18.57,99.49 17.92,99.49 17.7,99.71 ED5702.1 ED5702.10 15.96,99.71 15.82,99.85 15.46,99.85 ER5704.2 14.75,99.95 11.95,99.95 HDMI1.12
HDMI_DDI_TX_CON_P0: length 17.7
  TOP w0.114: v2(13.6,98.08) 13.99,98.08 v1(14.18,97.89)
  L3 w0.089: v2(13.6,98.08) 13.3,98.38 13.18,98.38 12.97,98.18 12.97,95.17 12.15,94.35 11.2,94.35 10.72,94.83 10.72,98.17 10.63,98.25 10.41,98.25 HDMI1.7
  BOTTOM w0.114: v2(13.6,98.08) 13.82,98.3 14.15,98.3 14.43,98.02 14.72,98.02 ER5703.1 15.32,97.96 15.76,97.96 16.01,97.71 ED5702.6 ED5702.5 17.6,97.71 17.72,97.83 17.99,97.83 18.17,97.65 18.53,97.65 18.69,97.49 EL5703.3
HDMI_DDI_TX_CON_P1: length 8.3
  BOTTOM w0.114: HDMI1.4 11.94,96.74 13.21,96.74 13.71,96.23 14.81,96.23 ER5702.1 15.37,96.3 15.76,96.3 15.88,96.18 ED5701.4 ED5701.7 17.7,96.18 17.79,96.26 18.42,96.26 18.74,95.94 EL5702.3
HDMI_DDI_TX_CON_P2: length 10.3
  BOTTOM w0.114: EL5701.3 18.56,94.39 18.36,94.59 18.2,94.59 18,94.78 17.72,94.78 17.6,94.66 ED5701.10 ED5701.1 15.95,94.66 15.83,94.78 15.73,94.78 15.59,94.65 15.41,94.65 ER5701.1 14.75,94.59 13.56,94.59 13.18,94.21 11.47,94.21 10.53,95.15 10.3,95.15 HDMI1.1
HDMI_DDI_TX_CON_P3: length 8.2
  BOTTOM w0.114: HDMI1.10 11.92,99.72 14.72,99.72 ER5704.1 15.28,99.62 15.73,99.62 16.12,99.23 ED5702.9 ED5702.2 17.7,99.23 17.74,99.27 18.52,99.27 18.72,99.07 EL5704.3
HDMI_DDI_TX_N0: length 70.8
  L5 w0.102: v2(62.94,98.77) 63.06,98.65 65.32,98.65 68.4,101.73 73.98,101.73 75.53,100.18 78,100.18 78.81,100.99 84.63,100.99 85.73,102.09 85.73,103.65 86.09,104.03 v2(86.15,104.03)
  BOTTOM w0.114: 60.05,99.13 60.44,99.52 61.82,99.52 62.57,98.77 v2(62.94,98.77) ; 60.05,99.13 58.05,97.13 56.88,97.13 52.26,92.51 40.21,92.51 38.76,93.96 29.44,93.96 28.69,94.71 25.21,94.71 C5777.1 ; 60.05,99.13 v1(59.95,99.24) ; CPU1.AL5 86.36,103.79 86.15,104 v2(86.15,104.03)
HDMI_DDI_TX_N1: length 66.5
  L5 w0.102: v2(85.21,103.51) 84.76,103.06 84.76,101.98 84.38,101.6 74.97,101.6 74.23,102.34 66.4,102.34 64.04,99.98 63.06,99.98 v2(62.94,100.09)
  BOTTOM w0.114: CPU1.AJ5 85.47,103.56 85.26,103.56 v2(85.21,103.51) ; C5779.1 24.5,96.87 25.85,96.87 26.17,97.18 ; v2(62.94,100.09) 62.24,100.09 61.46,100.86 49.38,100.86 48.62,100.1 29.09,100.1 26.17,97.18 ; v1(26.06,97.28) 26.17,97.18
HDMI_DDI_TX_N2: length 67
  L5 w0.102: v2(62.94,101.47) 62.56,101.09 62.33,101.09 62.16,101.27 62.16,102.08 62.4,102.83 63.12,103.56 65,104.34 65.01,104.35 68.59,104.75 68.61,104.76 68.64,104.77 68.81,104.82 68.84,104.83 69.23,105.12 71.66,106.05 82.11,106.05 83.85,104.31 83.85,103.19 84.19,102.85 v2(84.28,102.85)
  BOTTOM w0.114: C5781.1 25.3,98.83 25.58,98.83 27.02,99.49 28.86,100.8 46.97,100.8 48.92,101.58 52.76,101.58 ; CPU1.AF6 84.14,102.85 v2(84.28,102.85) ; 52.76,101.58 61.83,101.58 62.28,101.12 62.58,101.12 v2(62.94,101.47) ; 52.76,101.58 v1(52.76,101.73)
HDMI_DDI_TX_N3: length 63.2
  L5 w0.102: v2(83.38,104.04) 83.25,104.04 83.15,104.14 83.15,104.44 81.95,105.63 78.93,105.63 78.93,105.63 71.92,105.63 69.58,104.51 69.01,103.94 65.5,103.94 63.98,102.41 63.29,102.41 v2(62.94,102.76)
  BOTTOM w0.114: 27.82,101.5 46.75,101.5 48.87,103.62 48.88,103.62 50.42,104.65 55.45,104.65 57.75,102.35 62.54,102.35 v2(62.94,102.76) ; 27.82,101.5 v1(27.82,101.65) ; 27.82,101.5 27.59,101.5 27.04,100.94 25.91,100.94 C5783.1 ; CPU1.AE5 83.13,103.79 83.38,104.03 v2(83.38,104.04)
HDMI_DDI_TX_P0: length 70.8
  L5 w0.102: v2(62.94,98.13) 63.26,98.45 65.41,98.45 68.48,101.53 73.89,101.53 75.44,99.98 78.08,99.98 78.9,100.79 84.72,100.79 85.93,102 85.93,103.15 v2(86.16,103.38)
  BOTTOM w0.114: C5778.1 25.09,94.48 28.59,94.48 29.34,93.73 38.66,93.73 40.12,92.28 52.35,92.28 56.98,96.9 58.14,96.9 60.53,99.29 61.37,99.29 ; v2(62.94,98.13) 62.88,98.07 62.56,98.07 62.44,98.2 62.44,98.58 61.73,99.29 61.37,99.29 ; CPU1.AL6 86.38,103.38 v2(86.16,103.38) ; v1(61.37,99.14) 61.37,99.29
HDMI_DDI_TX_P1: length 66.5
  L5 w0.102: v2(85.25,102.87) 85.07,102.87 84.97,102.77 84.97,101.9 84.47,101.4 74.88,101.4 74.14,102.13 66.48,102.13 64.12,99.77 63.26,99.77 v2(62.94,99.45)
  BOTTOM w0.114: 27.27,97.96 25.95,96.64 24.58,96.64 C5780.1 ; 27.27,97.96 29.18,99.87 48.71,99.87 49.48,100.64 61.37,100.64 62.14,99.86 62.54,99.86 v2(62.94,99.45) ; 27.27,97.96 v1(27.37,97.85) ; v2(85.25,102.87) 85.43,102.87 CPU1.AJ6
HDMI_DDI_TX_P2: length 67
  L5 w0.102: v2(62.94,100.84) 62.89,100.89 62.25,100.89 61.95,101.19 61.95,102.12 62.22,102.94 62.25,102.98 62.98,103.7 63.01,103.73 64.96,104.55 68.54,104.95 68.74,105.02 68.81,105.07 69.11,105.29 69.14,105.3 71.62,106.26 82.19,106.26 84.05,104.4 84.05,103.65 84.22,103.48 v2(84.28,103.48)
  BOTTOM w0.114: CPU1.AF5 84.16,103.48 v2(84.28,103.48) ; 25.92,98.74 27.12,99.29 27.13,99.29 28.94,100.57 47.01,100.57 48.97,101.35 61.73,101.35 62.19,100.89 62.89,100.89 v2(62.94,100.84) ; 25.92,98.74 25.63,98.6 25.3,98.6 C5782.1 ; 25.92,98.74 v1(25.99,98.6)
HDMI_DDI_TX_P3: length 63.2
  L5 w0.102: v2(83.36,103.4) 83.36,103.44 82.94,103.86 82.94,104.35 81.87,105.43 79.02,105.43 79.01,105.42 71.96,105.42 69.7,104.34 69.09,103.73 65.59,103.73 64.06,102.21 63.03,102.21 v2(62.94,102.12)
  BOTTOM w0.114: CPU1.AE6 83.11,103.23 83.29,103.4 v2(83.36,103.4) ; 52.71,104.42 55.36,104.42 57.66,102.12 v2(62.94,102.12) ; 52.71,104.42 50.49,104.42 49.01,103.43 46.85,101.27 27.69,101.27 27.13,100.71 25.91,100.71 C5784.1 ; 52.71,104.42 v1(52.71,104.27)
HDMI_HPD_B: length 5
  BOTTOM w0.089: R5781.1 15.8,108.36 v1(15.24,107.8) 15.24,107.32 15.85,106.71 15.85,105.99 15.85,105.02 Q5703.B
HDMI_HPD_CON: length 27.4
  TOP w0.089: v2(12.96,101.75) 12.96,97.38 15.26,95.07 15.85,95.07 16.17,95.39 ED5703.5 ED5703.6 v1(17.58,94.61)
  L5 w0.089: HDMI1.19 10.61,103.85 10.95,104.19 12.27,104.19 12.96,103.51 v2(12.96,101.75)
  BOTTOM w0.089: HDMI1.19 10.34,104.19 12.68,104.19 13.24,104.75 13.92,104.75 14.84,103.84 15.62,103.84 16.03,104.24 16.03,105.91 16.03,107.34 R5781.2 16.18,107.6 R5764.1
HDMI_PLL_GND: length 24.8
  TOP w0.508: v2(23.5,95.56) 23.5,94.92 22.99,94.41 22.13,94.41 21.8,94.74 Q5701.D
  L3 w0.508: v2(23.35,97.89) 25.33,99.88 v2(26.22,99.88) 26.22,99.92 25.02,101.12 25.02,101.14 24.34,101.83 v2(24.34,102.03) ; v2(23.52,93.45) 23.5,93.47 v2(23.5,95.56)
  L6 w0.508: v2(23.35,97.89) 23.5,97.74 v2(23.5,95.56)
  BOTTOM w0.305: R5775.2 22.91,99.62 R5778.2 23.47,99.7 26.03,99.7 v2(26.22,99.88) ; R5777.2 24.31,102.06 v2(24.34,102.03) ; R5773.2 21.85,97.69 22.28,97.69 R5776.2 22.71,97.38 23.22,97.89 v2(23.35,97.89) ; v2(23.5,95.56) R5705.2 22.41,95.35 21.97,95.35 R5774.2
  BOTTOM w0.356: v2(26.22,99.88) v1(26.82,100.12)
  BOTTOM w0.508: R5759.2 23.07,92.99 v2(23.52,93.45)
HDMI_SCL_CON: length 27
  TOP w0.114: HDMI1.15 10.64,102.49 10.64,103.33 11.25,103.94 12.5,103.94 14.62,101.82 14.62,99.12 16.35,97.39 ED5703.1 ED5703.10 17.85,97.39 18.38,96.86 18.38,93.49 v1(17.85,92.96) 17.47,92.57 17.47,91.44 18.04,90.86 19.65,90.86 20.2,90.31 20.2,89.56 19.99,89.36 R5755.2 20.12,88.83 21.32,90.03 Q5702.3
HDMI_SCL_R: length 3
  TOP w0.114: D5701.2 19.13,89.37 R5755.1 19.93,88.03 v1(20.55,88.03)
HDMI_SDA_CON: length 27.2
  TOP w0.114: Q5702.6 22.62,88.21 22.08,87.66 18.84,87.66 v1(18.77,87.73) 18.09,88.41 R5751.2 19.04,89.78 19.04,90.45 18.91,90.58 17.96,90.58 17.12,91.42 17.12,93.24 18.04,94.16 18.04,96.7 17.83,96.91 ED5703.9 ED5703.2 16.3,96.91 14.28,98.93 14.28,101.75 12.84,103.19 12.39,103.19 HDMI1.16
HDMI_SDA_R: length 2.2
  TOP w0.114: D5701.1 17.22,89.37 R5751.1 v1(17.57,87.94)
HOST_DEBUG_TX: length 52.7
  TOP w0.089: v2(31.7,46.62) 31.98,46.33 v1(31.98,44.27) 32.2,44.05 32.95,44.05 33.2,44.3 R6801.1 ; DBEC1.5 47.61,73.83 47.8,74.01 49.36,74.01 49.56,73.81 49.65,73.81 50.02,73.44 50.02,72.9 47.78,70.66 46.86,70.66 46.68,70.48 45.57,70.48 44.55,69.46 44.55,68.52 44.58,68.49 44.58,65.24 43,63.65 v2(42.57,63.65) 42.27,63.65 41.79,64.14 41.79,64.67 R2480.1 39.96,66.49 U2401.81
  L5 w0.089: v2(31.7,46.62) 31.25,47.07 31.25,47.85 30.89,48.21 30.89,50.17 35.61,54.89 35.61,56.69 37.74,58.82 37.74,58.86 40.44,61.56 40.44,62.13 40.44,62.36 41.74,63.65 v2(42.57,63.65)
HOST_DEBUG_TX_CON: length 6.8
  TOP w0.089: R6801.2 v1(33.2,46.92) 33.2,48.97 31.61,50.57 DBG1.11
HPDIN: length 5.4
  TOP w0.089: U7101.32 19.8,106.79 19.74,106.73 19.5,106.73 19.5,106.74 18.83,106.74 v1(18.82,106.73) 18.6,106.73 v2(18.14,107.19)
  BOTTOM w0.089: R7176.1 17.4,108.61 17.4,107.57 17.78,107.19 v2(18.14,107.19) 18.34,106.99 R7190.2
HW_ACAV_IN: length 387.9
  TOP w0.089: D6403.K 50.8,64.75 50.3,65.25 50.3,65.86 49.66,66.5 49.66,67.84 49.27,68.23 49.27,69.5 50.19,70.43 50.57,70.43 v2(51.23,71.1) ; PG4408.2 209.29,42.75 v2(208.23,43.82) ; v2(25.27,72.86) 25.15,72.98 U2401.128 ; R4482.1 26.1,120.37 25.58,119.85 v2(25.58,119.76)
  L5 w0.089: v2(168.24,33.78) 167.78,34.25 162.55,34.25 162.43,34.36 151.2,34.36 150.47,33.63 148.13,33.63 147.58,34.18 139.93,34.18 139.1,33.36 137.93,33.36 136.66,34.62 135.13,34.62 132.24,37.51 130.7,37.51 124.95,43.26 112,43.26 110.28,41.55 110.28,37.93 109.6,37.25 109.6,36.28 108.4,35.08 108.32,35.08 105.27,32.04 92.72,32.04 92.58,32.18 87.62,32.18 86.15,30.7 37.34,30.7 34.73,28.09 34.73,26.73 34.04,26.04 32.85,26.04 30.84,24.02 21.57,24.02 19.67,25.92 16.31,25.92 14.34,27.89 14.34,35.02 14.08,35.28 14.08,37.89 11.26,40.71 11.26,45.82 14.2,48.77 14.2,51.51 14.33,51.64 14.33,57.41 18.24,61.32 18.24,62.38 v2(18.65,62.79) 19.22,63.37 19.22,64.96 19.21,64.98 19.21,65.33 19.87,65.99 19.87,68.03 20.68,68.84 21.26,68.84 23.14,70.72 23.14,71.16 24.84,72.86 v2(25.27,72.86) 28.12,75.71 29.03,75.71 29.73,76.4 36.9,76.4 38.48,77.98 38.48,91.26 36.24,93.5 30.57,93.5 29.72,94.35 29.72,99.35 26.17,102.91 26.17,113.82 26.09,113.9 26.09,115.16 25.61,115.65 25.61,119.71 25.58,119.74 v2(25.58,119.76)
  L6 w0.089: v2(168.24,33.78) 168.84,33.18 183.73,33.18 185.97,35.42 192.39,35.42 198.46,41.49 201.28,41.49 201.6,41.8 204.58,41.8 206.13,43.36 207.78,43.36 v2(208.23,43.82)
  BOTTOM w0.089: v2(18.65,62.79) 18.75,62.69 v1(19.31,62.69) 20.91,62.69 21.44,63.22 21.44,63.42 22.12,64.1 24.49,64.1 24.59,64.01 25.89,64.01 26.23,63.66 27.97,63.66 29.8,65.48 30.31,65.48 32.37,67.54 32.76,67.54 34.57,69.35 34.57,69.97 35.51,70.91 38.1,70.91 39.24,72.05 47.48,72.05 48.14,71.4 49.12,71.4 49.32,71.2 51.13,71.2 v2(51.23,71.1) ; PQ4415.5 207.93,43.51 v2(208.23,43.82)
HW_ACAV_IN0: length 2.3
  TOP w0.254: R4481.1 R4482.2 27.5,120.39 Q4449.2
HW_ACAVIN_NB: length 103.4
  TOP w0.089: v2(34.79,132.63) 34.79,133 D4305.A 33.99,133.33 R4315.2 34.37,132.03 R4311.2 35.12,132.03 R4471.2 ; U2401.24 23.13,63.29 22.79,62.95 22.79,62.79 v1(22.43,62.43) 21.77,62.43 20.81,63.4 v2(20.81,63.48) ; v2(37.14,118.97) 37.4,118.71 R4378.2 37.43,118.39 U4302.1
  L5 w0.089: v2(37.14,118.97) 38.66,117.45 38.66,104.75 39.37,104.05 39.37,95 40.62,93.74 40.62,77.12 36.37,72.87 35.9,72.87 35.39,72.36 35.39,71.83 33.43,69.88 32.63,69.88 31.5,68.74 31.5,68.4 30.55,67.45 29.43,67.45 28.92,66.94 28.92,65.57 v2(27.61,64.26)
  L6 w0.089: v2(31.88,121.44) 31.19,122.12 28.73,122.12 28.6,122.25 28.6,127.03 34.19,132.63 v2(34.79,132.63)
  BOTTOM w0.089: v2(20.81,63.48) 20.98,63.48 22.08,64.57 24.23,64.57 24.7,65.04 26.84,65.04 v2(27.61,64.26) ; v2(37.14,118.97) 35.66,120.45 32.87,120.45 v2(31.88,121.44)
HW_ACAVIN_NB0: length 17.3
  TOP w0.254: v2(36.73,132.04) 36.68,131.99 R4471.1 ; Q4449.5 29.94,120.39 30.53,120.97 R4470.1 30.83,121.41 v2(31.17,121.41)
  L6 w0.254: v2(31.17,121.41) 31.65,120.93 32.67,120.93 33.33,121.58 33.33,122.84 36.73,126.24 v2(36.73,132.04)
I2C0_SCL_TCH_PAD: length 204.2
  TOP w0.114: R2066.2 115.57,99.47 v2(115.87,99.77) ; v2(106.07,30.23) 105.92,30.38 v1(105.92,32.01) 106.68,32.77 106.68,34.85 EC6504.1 105.36,36.17 R6505.1 103.89,37.31 103.89,38.19 104.77,39.07 104.77,39.41 104.78,39.42 104.78,41.96 v2(104.65,42.09)
  L6 w0.114: v2(115.87,99.77) 115.87,99.62 116.4,99.1 116.4,99 117.15,98.24 117.15,97.4 117.18,97.37 117.18,94.79 118.41,93.56 118.41,91.77 117.87,91.22 117.87,87.16 116.17,85.46 116.17,74.57 123.16,67.58 123.16,65.95 129.14,59.97 165.36,59.97 165.83,60.44 167.4,60.44 168.89,58.95 169.85,58.95 170.72,58.09 170.72,55.78 170.28,55.35 170.28,44.19 169.58,43.49 136.82,43.49 136.82,43.49 129.16,43.49 126.77,45.87 110.77,45.87 109.64,44.75 107,44.75 104.65,42.4 v2(104.65,42.09)
  BOTTOM w0.076: 114.96,99.65 114.63,99.65 114.3,99.98 113.41,99.98 113.35,99.96 113.11,99.96 113.08,99.97 113.05,99.98 112.81,99.98 CPU1.CN11
  BOTTOM w0.114: v2(115.87,99.77) 115.75,99.65 114.96,99.65 ; Q6504.1 97.93,32.42 97.46,31.95 97.46,30.84 97.79,30.51 98.09,30.51 98.32,30.28 98.32,29.62 99.44,28.51 104.56,28.51 106.07,30.02 v2(106.07,30.23)
I2C0_SCL_TCH_PNL: length 196.4
  TOP w0.114: v2(169.14,35.22) 169.14,35.41 AFTP5504.1 ; R5518.2 222.71,47.45 v2(220.11,50.05)
  L5 w0.114: v2(109.8,99.02) 110.44,98.38 113.18,98.38 113.54,98.02 114.32,98.02 114.49,98.2 116.7,98.2 117.4,97.49 117.4,97.38 117.78,97.01 117.8,97.01 118.25,96.57 118.25,96.54 119.27,95.52 119.27,91.96 120.26,90.96 121.16,90.06 121.16,88.81 122.72,87.25 122.72,82.29 119.76,79.33 119.76,74.17 125.22,68.71 125.68,68.71 130.74,63.65 158.09,63.65 158.4,63.96 164.31,63.96 165.12,63.15 167.44,63.15 169.6,60.99 169.6,59.74 171.2,58.14 171.2,56.46 173.61,54.05 173.61,51.65 171.25,49.3 171.25,43.79 170.02,42.55 169.94,42.55 169.06,42.55 168.93,42.55 167.95,42.55 167.47,42.07 v2(167.47,41.63) ; v2(220.11,50.05) 219.59,50.05 217.86,48.32 217.86,46.94 214.75,43.83 214.75,42.63 211.49,39.37 202.71,39.37 202.44,39.11 202.08,39.11 201.82,39.37 201.22,39.37 199.74,40.86 197.87,40.86 197.33,40.31 197.33,40.31 197.05,40.03 194.53,40.03 193.41,41.15 192.22,41.15 192.22,41.15 191.73,41.15 191.3,41.58 189.81,41.58 188.65,40.42 188.65,39.08 185.74,36.16 183.52,36.16 182.78,36.91 178.88,36.91 177.85,35.89 174.84,35.89 174.79,35.93 169.69,35.93 169.14,35.38 v2(169.14,35.22)
  BOTTOM w0.114: CPU1.CJ12 109.8,99.03 v2(109.8,99.02) ; LCD1.15 v2(220.11,50.05) ; v2(167.47,41.63) 169.26,39.83 169.26,35.34 v2(169.14,35.22)
I2C0_SDA_TCH_PAD: length 199.6
  TOP w0.114: v2(104.02,42.09) 104.52,41.58 104.52,39.17 103.64,38.28 103.64,37.23 104.27,36.59 R6506.1 103.76,35.66 103.76,34.78 v1(103.76,31.93) 103.76,31.19 EC6502.1 104.47,30.48 v2(104.47,30.22) ; R2065.2 116.34,99.46 v2(116.61,99.74)
  L6 w0.114: v2(116.61,99.74) 116.61,99.09 117.37,98.33 117.37,97.86 117.37,97.86 117.37,97.49 117.4,97.46 117.4,94.94 118.63,93.7 118.63,91.62 118.08,91.07 118.08,87.07 116.39,85.37 116.39,74.78 117.25,73.92 124.52,66.64 125.19,66.64 127,66.64 130.88,62.76 131.05,62.76 158.42,62.76 158.87,62.31 161.55,62.31 161.65,62.42 165.76,62.42 169,59.17 169.94,59.17 170.93,58.18 170.93,55.64 170.51,55.22 170.51,44.11 169.67,43.27 128.98,43.27 126.59,45.66 110.9,45.66 109.7,44.45 107.16,44.45 105.36,42.66 105.36,42.18 104.83,41.65 104.45,41.65 v2(104.02,42.09)
  BOTTOM w0.076: 115.03,99.35 114.66,99.35 114.19,99.82 113.44,99.82 113.39,99.8 113.38,99.79 113.08,99.79 113.07,99.8 113.02,99.82 112.57,99.82 112.18,100.21 CPU1.CM11
  BOTTOM w0.114: v2(104.47,30.22) 104.47,30 104.47,30 104.47,29.52 103.95,28.99 100.23,28.99 99.65,29.56 99.65,30.42 99.23,30.85 Q6504.4 ; v2(116.61,99.74) 116.23,99.35 115.03,99.35
I2C0_SDA_TCH_PNL: length 193.2
  TOP w0.114: v2(219.71,49.55) 222.28,46.98 222.28,42.57 222.41,42.44 223.83,42.44 R5517.2 ; v2(168.1,41.66) AFTP5505.1
  L5 w0.114: v2(219.71,49.55) 219.71,48.45 214.99,43.73 214.99,42.53 211.45,38.99 202.67,38.99 202.54,38.87 201.98,38.87 201.86,38.99 200.76,38.99 199.77,39.98 198.65,39.98 198.61,40.03 197.38,40.03 197.15,39.79 194.43,39.79 194.21,40.01 189.92,40.01 185.84,35.92 183.38,35.92 182.63,36.67 178.98,36.67 177.95,35.64 174.47,35.64 174.43,35.69 170.09,35.69 169.78,35.38 v2(169.78,35.22) ; v2(110.46,99.01) 110.87,98.6 113.27,98.6 113.62,98.25 114.24,98.25 114.4,98.41 116.61,98.41 116.61,98.41 116.79,98.41 117.62,97.58 117.62,97.47 117.87,97.23 117.93,97.23 118.49,96.67 118.49,96.64 119.51,95.62 119.51,93 122.97,89.55 122.97,82.19 120,79.23 120,74.27 125.28,68.99 125.74,68.99 130.84,63.89 157.84,63.89 158.16,64.2 164.46,64.2 165.26,63.4 167.53,63.4 169.84,61.09 169.84,59.84 171.44,58.24 171.44,56.73 173.85,54.32 173.85,51.55 171.5,49.21 171.5,43.7 170.12,42.31 169.94,42.31 169.56,42.31 169.03,42.31 169.03,42.31 168.75,42.31 v2(168.1,41.66)
  BOTTOM w0.114: v2(110.46,99.01) 110.46,99.05 CPU1.CK12 ; v2(169.78,35.22) 169.5,35.49 169.5,40.25 v2(168.1,41.66) ; LCD1.16 v2(219.71,49.55)
I2C1_SCL_R: length 18.3
  TOP w0.114: RN6503.3 105.44,29.73 v2(105.44,30.24) 105.44,32.21 106.3,33.07 AFTP6528.1 105.33,34.47 v2(105.2,34.6) 105.03,34.76 R6505.2
  BOTTOM w0.114: v2(105.44,30.24) 105.44,29.73 104.46,28.75 99.54,28.75 98.56,29.72 98.56,30.38 97.93,31.01 Q6504.6 ; v2(105.2,34.6) TP1.6
I2C1_SDA_R: length 16.8
  TOP w0.114: R6506.2 104.27,34.67 v2(104.2,34.6) 104.52,34.27 AFTP6527.1 104.96,33.28 104.96,29.68 RN6503.4 104.08,29.58 103.84,29.82 v2(103.84,30.23)
  BOTTOM w0.114: Q6504.3 99.23,32.37 99.63,31.97 99.89,31.3 99.89,29.66 100.17,29.39 103.28,29.39 103.84,29.95 v2(103.84,30.23) ; TP1.7 v2(104.2,34.6)
I2C_CLK: length 29.8
  TOP w0.114: v1(33.15,104.09) v2(33.15,103.53) 33.61,103.07 33.61,102.67 33.27,102.33 Q5801.4 ; U5802.1 46.9,115.12 46.64,114.86 v2(46.38,114.86) 45.93,114.4 45.93,113.41 R5834.2
  L6 w0.114: v2(33.15,103.53) 33.9,104.28 38.78,104.28 39.56,105.07 44.08,105.07 45.25,106.24 45.25,109.26 44.05,110.46 44.05,112.81 45.02,113.77 46.58,113.77 46.83,114.03 46.83,114.41 v2(46.38,114.86)
I2C_CLK_PD: length 14.5
  TOP w0.114: U7201.17 38.24,109.66 37.92,109.34 36.71,109.34 RN7202.3 36.64,108.79 36.51,108.66 v2(36.22,108.66) ; R7114.2 26.91,108.9 27.79,108.9 v1(28.14,109.25) 28.3,109.42 v2(28.3,109.83)
  L6 w0.114: v2(36.22,108.66) 36.22,109.23 35.74,109.71 32.41,109.71 32.21,109.91 32.19,109.91 32.07,110.03 30.93,110.03 30.81,109.91 28.38,109.91 v2(28.3,109.83)
I2C_CLK_PD_MUX: length 2.8
  TOP w0.114: U7101.21 23.4,108.97 23.76,109.33 v1(24.66,109.33) 24.94,109.33 25.1,109.49 25.47,109.49 R7114.1
I2C_CTL_EN: length 14.9
  TOP w0.089: v2(46.4,114.21) 46.74,114.56 46.84,114.56 47.3,115.02 U5802.2
  BOTTOM w0.089: R5812.2 56.52,116.18 55.55,115.22 R5821.2 55.2,114.76 55.35,114.61 v1(55.35,114.35) 55.35,114.28 53.52,112.45 48.16,112.45 v2(46.4,114.21)
I2C_DATA_PD: length 13.8
  TOP w0.114: R7116.2 27.66,110.08 27.66,110.08 v2(27.69,110.08) ; v2(36.83,110.59) 36.64,110.4 RN7202.4 37.03,109.94 37.19,109.78 v1(37.67,109.78) 37.85,109.78 38.23,110.16 U7201.16
  L6 w0.114: v2(27.69,110.08) 27.87,110.27 28.49,110.27 28.62,110.14 30.73,110.14 30.84,110.25 32.16,110.25 32.27,110.14 32.29,110.14 32.5,109.93 36.17,109.93 v2(36.83,110.59)
I2C_DATA_PD_MUX: length 3.6
  TOP w0.114: R7116.1 25.38,109.78 v1(23.52,109.78) 23,109.26 U7101.22
I2C_SDA: length 30
  TOP w0.114: R5817.2 45.55,114.05 45.55,114.68 v2(46.37,115.5) U5802.60 ; Q5801.1 35.22,101.03 35.51,101.32 35.51,103.08 v2(35.06,103.53) v1(35.06,104.09)
  L6 w0.114: v2(46.37,115.5) 46.38,115.5 47.05,114.83 47.05,113.94 46.67,113.56 45.11,113.56 44.27,112.72 44.27,110.61 45.47,109.41 45.47,106.15 44.17,104.85 39.65,104.85 38.87,104.07 35.59,104.07 v2(35.06,103.53)
I2CB_SCL: length 25.4
  BOTTOM w0.114: RN7905.3 139.93,107.31 140.22,107.61 140.71,107.61 142.32,109.22 143.11,109.22 145.55,111.66 145.55,114.43 142.62,117.35 139.14,117.35 137.59,118.9 v1(137.59,119.03) 137.33,119.29 137.33,119.76 137.39,119.81 137.39,120.48 136.15,121.72 136.15,122.18 136.6,122.63 GPU1.C9
I2CB_SDA: length 22.8
  BOTTOM w0.114: RN7905.4 140.6,107.12 142.34,108.87 143.09,108.87 145.79,111.56 145.79,114.53 142.71,117.6 141.13,117.6 v1(140.08,118.64) 139.89,118.64 138.54,119.99 138.54,120.31 137.47,121.39 137.47,121.56 137,122.03 GPU1.C8
I2CC_SCL: length 20.8
  BOTTOM w0.114: RN7904.4 142.12,107.73 142.42,108.03 142.94,108.03 146.27,111.36 146.27,114.73 142.55,118.45 v1(142.55,118.49) 141.84,118.49 141.07,119.25 139.89,119.25 139,120.14 139,120.72 GPU1.A9
I2CC_SDA: length 21.8
  BOTTOM w0.114: GPU1.B9 137.82,121.9 137.82,121.37 138.76,120.43 138.76,120.08 139.81,119.03 140.77,119.03 141.33,118.47 ; 141.33,118.47 141.89,117.91 142.75,117.91 146.03,114.63 146.03,111.46 143.03,108.46 142.28,108.46 141.45,107.63 RN7904.3 ; 141.33,118.47 v1(141.33,118.47)
I2CEN: length 4.5
  TOP w0.089: U7101.17 v2(24.63,106.79)
  BOTTOM w0.089: R7174.2 23.07,107.8 23.83,107.04 C7166.2 23.85,107.01 R7173.1 23.95,106.13 v1(24.81,106.13) 24.81,106.61 v2(24.63,106.79)
I_ADP: length 7.4
  TOP w0.089: C2435.1 37.26,77.12 R2421.2 36.44,77.12 36.02,76.69 35.98,76.69 35.11,75.82 32.98,75.82 v1(32.53,75.37) 32.53,74.79 32.35,74.62 U2401.110
I_BATT: length 3.2
  TOP w0.203: v1(30.61,75.24) 30.76,75.09 U2401.114
  TOP w0.254: v1(30.61,75.24) 30.61,76.15 C2431.1 31.47,76.23 R2483.2
IC_DELAY: length 2.1
  TOP w0.089: v1(41.1,115.42) 41.18,115.42 C4344.1 41.33,116.49 U4302.4
ICSP_CLK: length 12
  TOP w0.114: DBEC1.2 43.47,75.33 43.17,75.03 42,75.03 42,75.03 41.7,75.03 41.7,75.03 40.81,75.03 40.66,74.87 v1(40.59,74.87) 40.01,74.87 39.86,74.72 39.07,73.93 38.17,73.03 37.79,73.03 37.28,72.51 37.28,72.4 36.81,71.93 35.81,71.93 35.56,72.18 35.56,72.82 35.95,73.21 U2401.101
ICSP_CLR: length 20.5
  TOP w0.089: DBEC1.6 47.62,73.33 48.13,73.83 49.28,73.83 49.49,73.63 49.58,73.63 49.79,73.42 49.79,72.92 47.71,70.84 46.79,70.84 46.6,70.66 45.21,70.66 43.44,68.89 R2414.1 42.8,68.81 v1(42.8,69.39) 42.52,69.67 40.54,69.67 39.76,68.89 U2401.87
ICSP_DAT: length 12.3
  TOP w0.114: U2401.102 35.55,73.16 35.32,72.92 35.32,72.08 35.71,71.69 36.91,71.69 37.52,72.3 37.52,72.41 37.88,72.77 38.26,72.77 39.17,73.69 39.96,74.47 40.8,74.47 41.07,74.75 41.77,74.75 v1(41.85,74.67) 41.87,74.67 41.99,74.79 43.27,74.79 43.31,74.83 DBEC1.3
ILIM_HI: length 2.9
  TOP w0.089: v2(23.78,51.72) 23.78,52.14 23.42,52.5 v1(23.35,52.5) 22.91,52.5 22.85,52.44 U3601.16
  BOTTOM w0.089: R3604.2 23.78,51.56 v2(23.78,51.72)
ILIM_LO: length 2.1
  TOP w0.089: U3601.15 22.81,51.94 R3603.2 23.63,51.13 v1(24,51.13)
ILIM_SEL: length 2.9
  TOP w0.089: R3605.2 v1(19.38,54.92) 20.01,54.29 U3601.4
IN_AUX_N: length 2.8
  TOP w0.114: U5802.25 55.63,117.63 55.72,117.55 55.99,117.55 56.34,117.2 56.34,116.7 56.52,116.52 56.71,116.52 C5854.2
IN_AUX_P: length 2.8
  TOP w0.114: U5802.24 55.64,117.23 55.72,117.32 55.9,117.32 56.11,117.1 56.11,116.61 56.42,116.3 56.71,116.3 C5862.2
INPUT3VSEL: length 103.2
  TOP w0.089: v2(160.51,57.76) v1(159.99,58.27) 158.67,59.6 156.63,59.6 154.17,62.06 154.17,65.51 150.89,68.78 145.6,68.78 145.42,68.61 144.38,68.61 143.61,69.38 R1521.1 143.65,70.23 R1520.2
  L6 w0.089: v2(160.51,57.76) 159.24,56.49 129.1,56.49 115.76,69.83 115.76,70.47 103.76,82.47 103.76,86.51 103.51,86.77 103.36,86.77 103,87.13 103,90.22 v2(102.64,90.58)
  BOTTOM w0.089: CPU1.BT27 102.64,90.57 v2(102.64,90.58)
INT#_ITE8010: length 14.8
  TOP w0.089: R2438.1 207.52,55.98 209.27,54.23 v1(210.72,54.23) 211.87,53.07 213.68,53.07 215.71,51.05 WWAN1.12
IO_DB_DET#: length 25.3
  L5 w0.089: v2(111.21,97.95) 112.88,97.95 113.19,97.64 114.22,97.64 114.58,97.99 116.61,97.99 117.2,97.41 117.2,96.22 118.79,94.63 118.79,91.89 120.93,89.74 v2(120.93,88.39)
  BOTTOM w0.089: AFTP6609.1 127,84.61 R6602.1 124.31,85.7 121.62,88.39 v2(120.93,88.39) ; v2(111.21,97.95) 111.52,98.26 CPU1.CM14
IO_DB_DET#_EC: length 228.1
  TOP w0.089: v2(25.71,60.73) 25.55,60.58 U2401.34 ; R6611.2 156.72,108.15 156.01,108.87 v1(154.79,108.87) 154.64,108.71 v2(154.64,108.26) 154.64,107.7 154.86,107.48 ; R6610.1 41.05,76.86 41.33,77.14 42.65,77.14 43.56,76.23 44.91,76.23 46.89,74.25 49.37,74.25 49.64,73.98 50.02,73.98 50.89,73.12 50.89,72.15 48.78,70.04 v2(48.56,70.04)
  L5 w0.089: v2(154.64,108.26) 154.38,108.51 154.38,108.94 153.19,110.13 152.83,110.13 152.47,109.77 149.07,109.77 148.98,109.69 147.95,109.69 147.86,109.78 136.03,109.78 119.82,125.99 119,125.99 116.7,123.68 116.7,117.02 115.52,115.84 108.82,115.84 108.65,116.02 106.71,116.02 104.57,113.88 104.57,110.14 106.32,108.39 106.32,105.51 105.31,104.5 105.31,103.94 105.1,103.73 105.1,101.68 105.1,101.68 105.1,100.22 104.82,99.94 101.24,99.94 100.34,100.84 86.95,100.84 85.68,99.58 75.21,99.58 74.33,100.45 67.97,100.45 65.36,97.83 65.36,97.61 65.15,97.4 62.95,97.4 62.41,97.94 62.41,98.76 62.02,99.15 61.03,99.15 60.18,98.3 60.18,97.73 57.52,95.07 56.04,95.07 54.52,93.55 54.52,92.98 51.67,90.13 51.67,89.26 52.15,88.78 52.15,74.64 51.34,73.83 51.34,72.01 50.8,71.48 50,71.48 v2(48.56,70.04)
  BOTTOM w0.089: v2(25.71,60.73) 27.98,58.46 27.98,55.78 28.55,55.2 30.4,55.2 31.82,56.63 31.82,64.97 32.69,65.84 32.69,66.95 34.91,69.17 38.25,69.17 39.82,70.73 45.74,70.73 46.89,69.59 48.11,69.59 v2(48.56,70.04)
IO_DB_DET#_GPPG5: length 30.5
  BOTTOM w0.089: CPU1.CH35 109.59,85.16 110.12,85.68 110.79,85.68 111.09,85.58 111.44,85.23 111.99,84.88 111.99,84.06 112.08,83.97 112.08,83.73 112.25,83.57 112.25,83.08 111.84,82.68 111.84,82.25 112.04,82.04 112.04,77.61 113.8,75.85 116.77,75.85 118.06,77.14 118.06,80.21 118.54,80.69 121.92,80.69 123.27,82.04 125.43,82.04 v1(125.78,82.4) 125.91,82.53 R6608.1
IO_DB_DET#_R: length 384.1
  TOP w0.089: R6610.2 40.77,76.07 41.35,76.66 v1(41.66,76.66) 41.71,76.61 v2(41.71,75.93)
  L5 w0.089: v2(139.96,33.58) 140.38,34.01 147.5,34.01 148.33,33.17 166.34,33.17 v2(166.95,33.78)
  L6 w0.089: v2(139.96,33.58) 139.96,34.09 139.91,34.13 139.91,35.45 137.7,37.67 129.41,37.67 128.8,38.28 127.96,38.28 123.79,42.44 112.84,42.44 111.23,40.84 111.23,36.95 108.42,34.14 107.5,34.14 104.43,31.07 90.82,31.07 89.22,29.47 41.44,29.47 37.22,25.25 22.85,25.25 20.7,27.4 20.7,35.53 19.11,37.12 19.11,58.92 21.42,61.22 21.42,65.43 20.89,65.96 20.89,66.5 25.73,71.34 28.21,71.34 29.67,72.8 38.76,72.8 41.71,75.75 v2(41.71,75.93) ; v2(202.78,37.82) 202.01,38.58 199.44,38.58 198.58,37.72 198.58,35.94 197.46,34.82 192.31,34.82 192.07,35.06 188.6,35.06 188.5,34.96 186.37,32.82 167.9,32.82 v2(166.95,33.78) ; v2(120.68,87.53) 120.2,87.05 119.59,87.05 117.37,84.83 117.37,75.19 124.93,67.62 127.41,67.62 130.91,64.12 163.5,64.12 164.13,63.48 167.38,63.48 170.97,59.89 170.97,59.26 171.72,58.51 171.72,54.88 171.31,54.47 171.31,43.77 169.66,42.11 166.68,42.11 v2(166.2,41.63)
  BOTTOM w0.089: v2(166.95,33.78) 166.95,34.13 166.35,34.72 166.35,36.58 166.39,36.61 166.39,39.8 166.39,39.97 165.95,40.41 165.95,41.39 v2(166.2,41.63) ; R6609.2 126.65,83.39 R6608.2 R6602.2 124.77,84.84 121.89,87.72 120.87,87.72 v2(120.68,87.53) ; IOBD1.2 202.8,37.84 v2(202.78,37.82)
IR_CAM_DET#: length 178.1
  TOP w0.089: v2(216.89,48.97) 216.54,48.62 R2046.2 ; AFTP5506.1 v2(166.93,35.03)
  L5 w0.089: v2(216.89,48.97) 217.32,48.55 217.32,46.78 214.35,43.82 213.82,43.82 213.16,43.16 213.16,41.36 211.48,39.68 203.6,39.68 203.29,39.99 201.77,39.99 200.43,41.33 198.02,41.33 197.23,40.54 197.23,40.54 196.95,40.26 194.62,40.26 193.5,41.38 192.12,41.38 191.83,41.38 191.4,41.81 189.66,41.81 188.41,40.55 188.41,39.84 188.41,39.16 185.65,36.4 183.62,36.4 182.5,37.52 175.03,37.52 173.78,36.26 173.68,36.16 169.48,36.16 168.35,35.03 v2(166.93,35.03) ; v2(111.31,92.66) 113.87,90.1 113.87,88.34 114.94,87.27 114.94,82.07 115.69,81.31 115.69,74.38 122.84,67.23 122.84,65.5 126.54,61.81 159.35,61.81 159.83,61.32 165.49,61.32 166.04,61.87 167.89,61.87 168.51,61.26 168.51,59.96 170.74,57.72 170.74,53.08 170.94,52.88 170.94,44.73 170.94,43.8 169.92,42.78 168.9,42.78 168.84,42.78 168.84,42.78 168.24,42.78 168.24,42.78 167.95,42.78 167.85,42.78 166.83,41.76 v2(166.83,41.63)
  BOTTOM w0.089: CPU1.CM22 111.31,92.91 v2(111.31,92.66) ; LCD1.18 218.33,48.55 217.91,48.97 v2(216.89,48.97) ; v2(166.83,41.63) 167.03,41.44 167.03,35.12 v2(166.93,35.03)
ISOLATE#: length 6.3
  TOP w0.089: U3101.20 48.8,83.34 v1(49.1,83.03) 49.52,82.62 v2(49.52,82.59)
  BOTTOM w0.089: R3109.2 49.21,79.71 49.21,80.78 49.6,81.17 49.6,81.9 49.52,81.98 v2(49.52,82.59) 49.52,82.62 49,83.14 R3113.1
IST_TRIG: length 9.3
  TOP w0.089: TP620.1 115.01,86.37 112.27,83.63 v2(112.27,82.5)
  BOTTOM w0.089: CPU1.CP36 112.93,84.46 112.75,84.29 112.75,83.62 v2(112.27,82.5)
ITP_PMODE: length 6.4
  BOTTOM w0.089: CPU1.W4 79.97,104.81 79.97,105.64 80.16,105.82 80.16,107.99 78.49,109.65 TP618.1
JACK_PLUG: length 19.8
  TOP w0.254: ED2911.1 18.24,7.95 v2(18.16,7.95) ; v2(14.74,10.09) 15.8,11.15 15.8,13.51 v1(16.39,14.1) 16.56,14.28 R2923.1 16.06,15.65 15.37,16.33 15.37,19.23 14.7,19.9 HPMIC1.5
  L3 w0.254: v2(18.16,7.95) 18.11,8 16.82,8 v2(14.74,10.09)
JACK_PLUG_DET: length 12.8
  TOP w0.254: R2914.1 17.88,18.9 v1(18.34,19.36) 18.86,19.87 ED2912.2 18.45,20.73 v2(17.81,20.73)
  L3 w0.254: HPMIC1.6 10.01,20.85 17.5,20.85 17.63,20.73 v2(17.81,20.73)
JGND:
  vias: v2(18.77,128.35) v2(19.66,128.35)
JIO3_PCIE_WAKE#: length 42.6
  TOP w0.089: R1806.2 40.57,95.43 AFTP6115.1 43.24,94.74 v2(43.42,94.93)
  L5 w0.089: v2(43.42,94.93) 43.09,94.93 41.72,93.56 41.72,80.47 42.36,79.82 42.36,77.8 42.36,75.95 v2(42.34,75.93)
  BOTTOM w0.089: WLAN1.55 44.45,95.96 v2(43.42,94.93) ; D1702.2 50.4,82.92 50.4,80.83 D2404.2 49.98,80.25 50.48,79.75 50.48,78.26 50.17,77.95 50.17,77.14 48.53,75.5 45.51,75.5 45.06,75.95 42.36,75.95 v2(42.34,75.93)
KB_BL_CTRL#: length 25.7
  TOP w0.356: v1(87.46,39.17) 87.61,39.17 88.01,38.76 v2(88.01,38.51)
  TOP w0.508: v2(106.45,39.93) 107.09,39.93 107.17,39.85 C6511.1 108.66,39.85 v2(108.84,39.68)
  L5 w0.381: v2(88.01,38.51) 88.01,38.41 88.49,37.94 92.97,37.94 93.95,38.91 96.42,38.91 97.03,38.3 101.75,38.3 101.95,38.51 103.36,38.51 104.78,39.93 v2(106.45,39.93)
  BOTTOM w0.305: v2(88.01,38.51) 88.01,38.46 88.34,38.13 KBBL1.4
  BOTTOM w0.508: Q6501.D v2(108.84,39.68)
KB_DET#: length 153.1
  TOP w0.089: v2(52.53,34.77) 52.96,35.2 52.96,35.59 52.26,36.28 52.26,50.67 56.84,55.25 97.2,55.25 97.58,54.87 110.8,54.87 125.84,69.9 125.84,96.7 124.39,98.16 124.39,99.42 123.96,99.85 123.96,100.48 124.41,100.94 v2(124.41,100.97) ; v2(56.92,33.61) 56.98,33.66 57.05,33.66 AFTP6567.1 57.56,35.41 R2045.2
  L3 w0.089: v2(111.34,100.09) 111.73,100.09 113.56,101.93 123.43,101.93 124.39,100.97 v2(124.41,100.97)
  BOTTOM w0.089: v2(111.34,100.09) 111.61,99.83 CPU1.CM12 ; v2(52.53,34.77) 53.39,34.77 54.12,35.5 KB1.30 54.32,35.07 55.78,33.61 v2(56.92,33.61)
KB_LED_BL_DET: length 221.4
  TOP w0.089: v1(87.85,31) v2(87.85,31.56)
  L3 w0.089: v2(175.52,52.63) 175.72,52.63 176.18,53.09 176.18,56.39 175.85,56.71 175.85,59.51 177.02,60.68 177.02,64.57 174.12,67.47 172.67,67.47 167.31,72.83 v2(167.31,73.69) ; v2(159.52,36.27) 159.79,36.55 162.85,36.55 163.28,36.12 165.53,36.12 166.15,36.74 168.11,36.74 168.47,36.37 170.44,36.37 v2(170.87,36.81)
  L6 w0.089: v2(170.87,36.81) 171.15,37.09 171.49,37.09 175.03,40.62 175.03,41.27 175,41.3 175,45.61 175.67,46.28 175.67,50.7 175.52,50.85 v2(175.52,52.63) ; v2(87.85,31.56) 88.55,32.25 103.91,32.25 108.54,36.88 108.54,38.76 109.41,39.63 109.41,40.42 112.51,43.52 124.42,43.52 128.44,39.51 129.33,39.51 129.89,38.95 142.44,38.95 145.58,35.8 147.45,35.8 148.8,34.45 148.99,34.45 149,34.44 156.82,34.44 156.93,34.55 158.12,35.74 158.98,35.74 v2(159.52,36.27)
  BOTTOM w0.076: CPU1.CK36 111.04,84.05 111.08,83.96
  BOTTOM w0.089: v2(167.31,73.69) 167.74,74.11 167.74,74.5 167.31,74.92 167.31,74.93 167.16,75.09 163.9,75.09 163.19,74.38 162.69,74.38 162.34,74.73 162.34,74.79 162.09,75.04 161.07,75.04 160.45,74.42 124.79,74.42 123.3,72.93 121.39,72.93 121.18,73.14 118.83,75.49 117.79,75.49 113.66,75.49 111.64,77.51 111.64,78.34 110.95,79.03 110.95,82.42 111.08,82.55 111.08,83.96 ; R6508.1 79.38,35.56 R6507.1 80.59,34.35 81.3,34.35 81.7,34.75 86.79,34.75 87.85,33.69 v2(87.85,31.56)
KB_LED_DET_C: length 11.6
  TOP w0.089: C6510.1 87.33,37.72 87.31,37.69 86.74,38.26 v2(86.74,38.53) 86.42,39.03 v1(86.13,39.09)
  BOTTOM w0.089: v2(86.74,38.53) 86.34,38.13 KBBL1.2 86.34,35.28 86.01,34.95 81.21,34.95 R6507.2
KB_LED_PWM: length 133.3
  TOP w0.089: v2(106.45,39.3) v1(107.5,39.3) ; U2401.44 29.56,59.93 27.79,61.7 v2(27.59,61.7)
  L5 w0.089: v2(27.59,61.7) 27.14,61.25 27.14,60.2 25.26,58.33 25.2,58.33 24.79,57.92 24.55,57.92 23.29,56.66 23.24,56.66 22.84,56.26 22.84,53.44 21.87,52.47 21.87,51.08 21.46,50.67 21.46,47.62 20.67,46.83 20.67,32.78 21.62,31.82 26.52,31.82 27.92,33.22 31.77,33.22 34.29,35.75 34.37,35.75 36.35,37.72 36.35,38.5 39.75,41.9 51.68,41.9 53.85,39.73 56.46,39.73 57.15,39.05 58.08,39.05 58.27,39.24 59.76,39.24 60.6,38.4 62.69,38.4 64.21,36.88 76.5,36.88 76.63,37.01 81.92,37.01 83.87,38.96 93.29,38.96 93.74,39.4 96.62,39.4 97.23,38.79 101.5,38.79 101.68,38.97 101.78,38.97 101.81,39 102.96,39 v2(103.25,39.3)
  L6 w0.089: v2(103.25,39.3) 103.64,38.91 105.29,38.91 105.67,39.3 v2(106.45,39.3)
  BOTTOM w0.089: v2(106.45,39.3) 106.62,39.3 106.75,39.16 107.2,39.16 107.52,38.84 Q6501.G
KBC_BEEP_R: length 2.3
  TOP w0.127: D2703.2 21.94,23.2 22.23,23.5 v1(22.23,23.91) 23.02,24.69 R2739.2
KBC_PWRBTN#: length 366.1
  TOP w0.089: v2(50.46,72.32) 50.24,72.32 48.14,70.22 48.14,69.44 Q6408.E ; v2(209.65,62.92) 209.28,62.54 RN6401.2 ; R2432.1 20.75,74.04 v2(20.73,74.02) ; v1(19.13,66.12) v2(18.57,66.12)
  L3 w0.089: v2(136.15,34.17) 137.78,32.54 144.15,32.54 145.31,33.7 149.73,33.7 150.93,34.89 165.87,34.89 166.61,35.63 167.65,35.63 168.72,34.56 173.29,34.56 175.5,32.36 176.26,32.36 189.28,32.36 190.02,31.62 197.92,31.62 200.43,34.13 205.97,34.13 209.47,37.63 212.31,37.63 212.82,37.13 215.63,37.13 216.19,37.69 216.2,37.69 216.59,38.08 217.03,38.08 218.16,38.08 218.92,38.84 218.92,56.59 214.19,61.32 212.54,61.32 211.38,62.47 210.1,62.47 v2(209.65,62.92)
  L5 w0.089: v2(136.15,34.17) 135.33,34.17 132.17,37.33 130.61,37.33 124.86,43.09 112.07,43.09 110.46,41.47 110.46,37.86 109.78,37.17 109.78,36.21 108.48,34.91 108.39,34.91 105.35,31.86 92.65,31.86 92.51,32 87.69,32 86.22,30.53 37.42,30.53 34.91,28.02 34.91,26.65 34.11,25.86 32.92,25.86 30.91,23.85 21.48,23.85 19.59,25.73 16.25,25.73 14.16,27.81 14.16,34.91 13.9,35.18 13.9,37.82 11.08,40.64 11.08,45.92 14.03,48.87 14.03,51.59 14.15,51.72 14.15,57.53 16.72,60.1 16.72,63.12 18.57,64.97 v2(18.57,66.12) 19.61,67.16 19.61,68.84 20.73,69.96 v2(20.73,74.02)
  BOTTOM w0.089: v2(50.46,72.32) 50.37,72.41 48.56,72.41 47.9,73.07 37.71,73.07 37.14,72.5 37.14,72.27 36.62,71.75 35.17,71.75 32.94,69.52 32.73,69.52 30.43,67.22 25.24,67.22 24.65,66.63 22.43,66.63 22.11,66.96 20.29,66.96 19.68,66.35 18.8,66.35 v2(18.57,66.12) ; FP1.2 220.45,63.43 220.83,63.81 220.83,64.47 220.58,64.72 220.09,64.72 219.46,64.09 219.31,64.09 212.2,64.09 210.52,62.41 210.16,62.41 v2(209.65,62.92)
