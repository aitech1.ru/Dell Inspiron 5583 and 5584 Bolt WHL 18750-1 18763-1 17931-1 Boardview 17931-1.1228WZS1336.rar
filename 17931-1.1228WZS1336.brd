# Allegro board 17931-1.1228WZS1336.brd (continued)
## Library data of the parts (continued)
C1223 C1227 C7611 C7613 C7620 C7621 C7813 C7814 C7934 C8001-C8004 C8008 C8009 C8015 C8016 C8019-C8026 C8030-C8032 C8048 PC4507 = C603H36: tolerance: 78.47520.5BL
C1228 C1328 C8802 C8805-C8809 = C402H22: tolerance: 78.10421.L0L
C1231 C1304 C1307 C1309 C1311 C1324 C1325 C2702 C2703 C2710 C2711 C2715 C5505 C5517 C7206 = C402-TO0D2H28: tolerance: 078.10610.05FD
C1329 C6405 C7165 C7217 EC1202 EC1303 FC1102 FC1103 R1216 = C402H22: tolerance: 78.22510.5FLDL
C1603 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1603
C1604 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1604
C1605 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1605
C1606 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1606
C1607 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1607
C1608 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1608
C1611 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1611
C1612 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1612
C1701 PC5212 = C402H22: tolerance: 78.22124.2FLDL
C1702 C1703 C7215 = C402H22: tolerance: 78.22423.5FL
C1803 C1804 = C402H22: tolerance: 78.12034.1FLDL
C1807 C1808 C3116 C3125 = C402H22: tolerance: 78.15034.1FLDL
C1809 = C402H22: tolerance: 78.2R274.1FLDL
C2208 C2231 = C603H40: tolerance: 078.47610.05BD
C2218 C2604 C2907 C2908 C3110 C3124 C7615 C7624 C7634 C9109 PC4421 PC4422 PC4520 = C603H36: tolerance: 78.47520.5BLDL
C2405 = C402H22: tolerance: 78.10134.1FL
C2409 C5810 PC4431 PC4613 PC4622 PC4635 PC4637 PC5213 PC8609 = C402H22: tolerance: 78.10322.2FLDL
C2424 C2425 = C402H22: tolerance: 78.18034.1FLDL
C2426 C2705 C2708 C2709 PC5001 = C603H36: tolerance: 78.22523.5BLDL
C2431 C2435 PC4443 = C402H22: tolerance: 78.22224.2FL
C2503 = C603H36: tolerance: 78.47422.5BL
C2517 PC4420 PC4608 PC4625 PC4626 PC4628 PC4652 PC4654 = C402H22: tolerance: 78.22321.2FLDL
C2601 = C402-TO0D2H28: tolerance: 78.10610.5FL
C2602 C2612 C2704 C2706 C2714 C2718 C2721 C2723 C2741 C6501 C6505 C7632 C7801 C7802 C7805 C7808 C7809 C7902 C7905 C7906 C8029 C8034 C8035 C8049 C8051 EC6401 EC8936 FC8918 FC8919 PC4518 PC8614 = C402H22: tolerance: 78.10421.2FL
C2603 C2607 C5531 C5535 PC4441 PC4601 PC4611 PC4612 PC4623 PC4632 PC4640 = C402H22: tolerance: 78.22224.2FLDL
C2605 C4033 C4034 C6106 C7166 C7201 C7302-C7304 C7307 C8603 EC2201 EC6402 EC6404 EC6405 PC4406 PC4513 PC4603 PC4631 PC4633 PC5004 PC5102 PC5122 PC5123 PC5127 PC5204 PC5208 PC5214 PC8503 PC8506 PC8551 PC8553 PC8556 PC8572 PC8575 = C402H22: tolerance: 78.10422.5FLDL
C2606 = C603H36: tolerance: 78.47134.1BL
C2613 = C402H22: tolerance: 78.10134.1FLDL
C2713 C2717 = C603H38: tolerance: 78.10613.5BL
C2740 = C603H36: tolerance: 78.22523.L1L
C3102 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C3102
C3104 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C3104
C3107 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C3107
C3109 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C3109
C3202 = C1808H56: tolerance: 78.1013N.1AL
C3203 C4303-C4305 PC4615 PC4620 PC4644 PC8554 = C402H22: tolerance: 78.10324.2FLDL
C3507 C3517 C3525 C4031 C4032 C4041 C7207 C7212 PC4607 PC4708 PC4766 PC4809 PC4812 PC4866 PC4877 PC5120 PC8550 = C402H22: tolerance: 78.10523.5FLDL
C3520 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C3520
C3521 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C3521
C3522 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C3522
C3523 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C3523
C4001 C4002 C4011 C4017 C5539 C5540 = C402H22: tolerance: 78.47124.2FL
C4004 C4014 C4306 C5514 C7305 EC4301 PC4402-PC4405 PC4413 PC4418 PC4427 PC4434 PC4437 PC4446-PC4448 PC4502-PC4504 PC5002 PC5003 PC5209-PC5211 PC5216 = C805H58: tolerance: 78.10622.51LDL
C4301 C4302 C7306 = C603H36: tolerance: 078.10524.05BD
C4344 C5513 EC2002 EC2901-EC2904 EC4302 EC4307 EC4308 EC4312 EC4313 EC6403 EC8969 PC4432 PC4435 PC4442 PC4445 PC4616 PC4617 PC4619 PC4642 PC4643 PC4651 PC4706 PC4810 PC4813 PC5215 PC8552 = C402H22: tolerance: 78.10224.2FLDL
C4444 C7401 FC8963 FC8964 = C402H22: tolerance: 78.15224.2FLDL
C5503 C5504 C5520 C5599 C7610 PC5121 = C402H22: tolerance: 078.47510.05FD
C5512 C5516 C5528 C5809 C7616 C8108 C8115-C8125 C8209-C8214 C8220-C8223 C8225 C8226 EC1203 EC4311 EC4534 EC8911-EC8915 EC8927 EC8930 EC8932 EC8957 EC8963 EC8964 EC8974 EC8976 FC8901 FC8902 FC8907-FC8911 FC8917 FC8922 FC8931-FC8942 FC8944-FC8948 FC8951-FC8960 FC8962 FC8965-FC8967 FC8970 FC8981 FC8983-FC8988 FC8990-FC8999 FC9001 PC4501 PC4506 PC4508 PC4521 PC4522 PC4530-PC4532 PC8619 = C402H22: tolerance: 78.10422.5FL
C5521 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5521
C5522 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5522
C5523 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5523
C5524 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5524
C5525 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5525
C5526 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5526
C5724 C8101 C8201 = C402H22: tolerance: 78.10324.2FL
C5777 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5777
C5778 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5778
C5779 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5779
C5780 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5780
C5781 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5781
C5782 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5782
C5783 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5783
C5784 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5784
C5801 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5801
C5802 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5802
C5803 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5803
C5804 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5804
C5805 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5805
C5806 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5806
C5807 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5807
C5808 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5808
C5854 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5854
C5862 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5862
C5863 = C402H22: tolerance: 78.22523.5FL
C6008 C6018 = C402-TO0D2H28: tolerance: 78.10613.5FLDL
C6010 = C402H22: tolerance: 78.10322.2FLDL; signal model: Graser_C6010
C6011 = C402H22: tolerance: 78.10322.2FLDL; signal model: Graser_C6011
C6013 = C402H22: tolerance: 78.10322.2FLDL; signal model: Graser_C6013
C6014 = C402H22: tolerance: 78.10322.2FLDL; signal model: Graser_C6014
C6028 = C402H22: tolerance: 78.10322.2FLDL; signal model: Graser_C6028
C6029 = C402H22: tolerance: 78.10322.2FLDL; signal model: Graser_C6029
C6030 = C402H22: tolerance: 78.10322.2FLDL; signal model: Graser_C6030
C6031 = C402H22: tolerance: 78.10322.2FLDL; signal model: Graser_C6031
C6102 = C603H36: tolerance: 78.47520.L0L
C6201 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C6201
C6202 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C6202
C6302 = C402H22: tolerance: 078.22423.05FD; signal model: Graser_C6302
C6303 = C402H22: tolerance: 078.22423.05FD; signal model: Graser_C6303
C6304 C6305 EC1903 EC5503 EC5504 PC4610 PC4624 PC4639 PC8573 = C402H22: tolerance: 78.33034.1FLDL
C6306 C6308 PC4605 PC4630 PC4634 PC4653 = C402H22: tolerance: 078.47322.02FD
C6311 = C402H22: tolerance: 078.22423.05FD; signal model: Graser_C6311
C6312 = C402H22: tolerance: 078.22423.05FD; signal model: Graser_C6312
C6313 = C402H22: tolerance: 078.22423.05FD; signal model: Graser_C6313
C6314 = C402H22: tolerance: 078.22423.05FD; signal model: Graser_C6314
C6315 = C402H22: tolerance: 078.22423.05FD; signal model: Graser_C6315
C6316 = C402H22: tolerance: 078.22423.05FD; signal model: Graser_C6316
C6506 C6510 C6511 EC1801 EC1901 EC2503 EC2504 EC2601 EC2602 PC4430 = C402H22: tolerance: 78.10034.1FLDL
C7107 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C7107
C7108 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C7108
C7109 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C7109
C7110 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C7110
C7111 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C7111
C7112 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C7112
C7113 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C7113
C7114 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C7114
C7161 = C402H22: tolerance: 78.10422.5FLDL; signal model: Graser_C7161
C7162 = C402H22: tolerance: 78.10422.5FLDL; signal model: Graser_C7162
C7163 = C402H22: tolerance: 78.10422.5FLDL; signal model: Graser_C7163
C7164 = C402H22: tolerance: 78.10422.5FLDL; signal model: Graser_C7164
C7167 = C0201H13: tolerance: 078.33410.05S1; signal model: Graser_C7167
C7168 = C0201H13: tolerance: 078.33410.05S1; signal model: Graser_C7168
C7169 = C0201H13: tolerance: 078.33410.05S1; signal model: Graser_C7169
C7170 = C0201H13: tolerance: 078.33410.05S1; signal model: Graser_C7170
C7208 C7209 = C402H24: tolerance: 78.39124.2FL
C7214 C7810-C7812 C7825-C7828 = C603H32: tolerance: 78.10524.5BL
C7405 EC8923-EC8925 EC8929 EC8955 EC8962 PC4526 PC4533 = C402H22: tolerance: 78.10224.2FL
C7601 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7601
C7602 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7602
C7603 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7603
C7604 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7604
C7605 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7605
C7606 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7606
C7607 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7607
C7608 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7608
C7626 C7628 C7818 C7820-C7822 C7935 C8010 C8017 C8047 PC8628 PC8631 = C603H40: tolerance: 78.22610.5BL
C7907 C7908 = C402H22: tolerance: 78.18034.1FL
C8103 C8202 = C402H22: tolerance: 78.82124.2FL
C8501 = CT7343H83: tolerance: 79.33612.20L
C8502 = CT3528H79: tolerance: 080.22612.0001
C8605 C8608 PC4433 PC4614 PC4618 = C402H22: tolerance: 78.47124.2FLDL
C8804 = C402H22: tolerance: 78.10324.L0L
CPU1 = BGA1528M2446-1H52: tolerance: ZZ.00CPU.271
D1701 PD4407 PD4409 = SOD523AKH26: tolerance: 83.R2003.A8M
D1702 D2404 D5701 = SOT23-2D4-312H44: tolerance: 75.00056.07D
D2401 D2501 D2703 D5502 D5503 PD4401 PD4408 = SOT-23-9H44: tolerance: 75.00054.A7D
D2402 D4001 D7902 D8801 D8803 PD4404 = SOD323AKH44: tolerance: 83.00355.G1F
D2403 D2502 D2601 D4002 D4003 D4305 = SOD323AKH38: tolerance: 83.R5003.H8H
D2503 D2901 D6401 = SOT-23-9H44: tolerance: 75.BAT54.07D
D4301 = D4724AKH44: tolerance: 083.00624.00AM
D4302 ED4304-ED4306 = SOT23-2D4-312H44: tolerance: 75.00099.O7D
D4304 = SOD123AK-2H43: tolerance: 83.SMF18.AAH
D5504 D5505 = D1608AK-UH28: tolerance: 83.R1004.D8F
D6403 = SOD323-2513AKH36: tolerance: 83.R2004.J8F
D7201 D7202 = D1006-0305AK-UH22: tolerance: 083.00520.0F8F
D7401 = SOD123AK-3718-1H40: tolerance: 083.03040.008H
DBEC1 = 50696-00601-001: tolerance: 20.K0691.006
DBG1 = 87212-1400N: tolerance: 20.F0765.014
DCIN1 = 50224-0080N-W02-U: tolerance: 20.F1295.008
DM1 DM2 = ADDR0206-P013A-1-U: tolerance: 062.10011.M001
EC1803 EC2501 EC2502 EC2505 EC2506 = C402H22: tolerance: 078.4R7B4.01FD
EC2701-EC2705 EC2905 EC2906 EC3513 EC4701 EC5001 EC6601 EC8901-EC8910 EC8961 EC8965-EC8968 EC8971-EC8973 = C402H22: tolerance: 78.10221.2FLDL
EC2706-EC2708 PC8632 = C402H22: tolerance: 78.22034.1FL
EC2907 EC2908 = C402H22: tolerance: 78.68124.2FLDL
EC4306 EC4309 EC4310 = C402H22: tolerance: 78.10034.1FL
EC6501-EC6504 = C402H22: tolerance: 78.33034.1FL
EC8933-EC8935 EC8937-EC8939 EC8947-EC8949 EC8986-EC8990 FC8903 FC8961 FC9002-FC9004 = C402H22: tolerance: 78.10523.5FL
ED301 ED2403 ED2910-ED2912 ED6401 ED7307 ED7315 = SOT23-2D4-312H46: tolerance: 75.05125.07D
ED1217 ED1302 = SOT23-2D4-312H44: tolerance: 075.52215.007D
ED1701-ED1703 ED1705-ED1707 ED1801 ED1802 = SOD-523-2H26: tolerance: 83.0005V.0AF
ED3201 ED3202 ED3501 ED3503 ED5701-ED5703 ED6001 = DFN10G2510H22: tolerance: 075.01043.0073
ED3502 ED5502 ED6601 ED9202 = SOT-6H58: tolerance: 075.09904.0A7C
ED4303 = SOD882-10D6-1H20: tolerance: 83.05725.0A0
ED7301 ED7302 = SLP2510P8-1H22: tolerance: 075.00550.0071
ED7311-ED7314 = SOD882-10D6-UH22: tolerance: 083.00201.0AAF
EL3501 = L125100-4P-4H24: tolerance: 68.00396.001; signal model: Graser_EL3501
EL3502 = L125100-4P-5H24: tolerance: 68.24500.201; signal model: Graser_EL3502
EL3503 = L125100-4P-5H24: tolerance: 68.24500.201; signal model: Graser_EL3503
EL3504 = L125100-4P-5H24: tolerance: 68.24500.201; signal model: Graser_EL3504
EL3505 = L125100-4P-5H24: tolerance: 68.24500.201; signal model: Graser_EL3505
EL3506 = L125100-4P-4H24: tolerance: 68.00396.001; signal model: Graser_EL3506
EL4301-EL4304 PR4414 R2701 R2736 R6001 R6003 = 0R0805-PAD: tolerance: ZZ.R0805.ZZZ
EL5501 = L125100-4P-4H24: tolerance: 68.00396.001; signal model: Graser_EL5501
EL5701 = L125100-4P-3H24: tolerance: 068.01210.2031; signal model: Graser_EL5701
EL5702 = L125100-4P-3H24: tolerance: 068.01210.2031; signal model: Graser_EL5702
EL5703 = L125100-4P-3H24: tolerance: 068.01210.2031; signal model: Graser_EL5703
EL5704 = L125100-4P-3H24: tolerance: 068.01210.2031; signal model: Graser_EL5704
EL6101 = L125100-4P-4H24: tolerance: 68.00396.001; signal model: Graser_EL6101
EL6601 = L125100-4P-4H28: tolerance: 68.01012.20B; signal model: Graser_EL6601
EL6602 = L125100-4P-4H28: tolerance: 68.01012.20B; signal model: Graser_EL6602
EL7105 = L125100-4P-4H24: tolerance: 68.00396.001; signal model: Graser_EL7105
EL7106 = L125100-4P-4H24: tolerance: 68.00396.001; signal model: Graser_EL7106
ER2701 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_ER2701
ER5701-ER5704 R2101 R6413 = R402H16: tolerance: 64.15005.6DL
F5503 = POLYSW-4633-UH43: tolerance: 69.50007.A31
F5504-F5506 F5701 F6501 = POLYSW-2114H30: tolerance: 69.48001.081
FAN1 SPK1 = 50224-0040N-001: tolerance: 20.F1639.004
FC8912-FC8916 FC8921 FC8923 FC8924 FC8929 FC8930 PC5111 = C402H22: tolerance: 78.68034.1FLDL
FP1 = FH52-8S-D5SH: tolerance: 20.K0767.008
G1801 G6401 G6402 = CON2O-U: tolerance: ZZ.CON2O.XXX
GPU1 = BGA595M23H83: tolerance: 071.0N17S.0000
H1-H7 = HOLE233R142: tolerance: ZZ.00PAD.5S1
H9 H10 H16 = HOLE335R178: tolerance: ZZ.00PAD.7F1
H11 H13 H14 H17 H18 = HOLE256R115: tolerance: ZZ.00PAD.D11
H12 = HOLE335R229: tolerance: ZZ.00PAD.7G1
HDA27 = QFN40J5-G3D75H36: tolerance: 071.03204.0003
HDD1 VGABD1 = 50406-02071-W01: tolerance: 020.F0320.0020
HDD2 = FFSKL05007N12C: tolerance: 020.K0222.0012
HDMI1 = SKT-HDMI23-188139-2: tolerance: 022.10025.0131
HPMIC1 = 14-00790-1A03-A: tolerance: ZZ.00SKT.020
HS3 = STF237R113H86: tolerance: 434.07K0E.0001
IOBD1 = 51530-02001-W01-U: tolerance: 20.K0637.020
JUSB1 = SKT-USB36-124102-1: tolerance: 022.10005.M022
KB1 = 50699-03001-W01: tolerance: 020.K0254.0030
KBBL1 = 50698-00401-W01-U: tolerance: 020.K0298.0004
L7101 = L402H24: tolerance: 68.00213.051
L7602 = L603H38: tolerance: 68.00335.151
L7801 L7901 = L603H38: tolerance: 68.00335.051
L7902 = L603H38: tolerance: 68.00909.261
LCD1 = 300E40-1010RA-G3: tolerance: 020.F0847.0040
LED1 = LED3020-3P-19H44: tolerance: 083.1212A.0070
LED2 = LED11516AKH28: tolerance: 83.00270.F70
MESW1 = MSS3-Q-T-R: tolerance: 62.40018.641
ODD1 = 50552-01601-001: tolerance: 020.K0386.0016
PC4407-PC4412 PC4414 PC8501 PC8502 PC8504 PC8505 PC8561 PC8562 PC8576 PC8578 = C603H40: tolerance: 078.10612.05BL
PC4415 = C603H40: tolerance: 078.47522.05B1
PC4416 PC4417 PC4419 PC4424-PC4426 PC4439 PC4440 = C603H36: tolerance: 78.10522.5BLDL
PC4423 PC4436 PC4606 PC4707 PC4808 PC4811 PC5005 = C603H36: tolerance: 78.22422.2BLDL
PC4429 = C402H22: tolerance: 78.47224.2FLDL
PC4505 PC4519 PC4523 PC8610 PC8615 = C805H56: tolerance: 78.10622.51L
PC4524 PC8617 = C603H36: tolerance: 78.22523.5BL
PC4604 PC4629 PC4638 PC4641 = C402H22: tolerance: 78.33124.2FLDL
PC4621 = C402H22: tolerance: 78.68124.2FL
PC4701-PC4704 PC4802-PC4805 PC4814-PC4817 = C603H40: tolerance: 78.10612.5BL
PC5103 = C402H22: tolerance: 78.10523.L2L
PC5104-PC5107 PC5301-PC5303 = C603H40: tolerance: 78.22610.L4L
PC5115 PC5119 = C805H56: tolerance: 78.10622.LAL
PC5116 PC5117 = C603H38: tolerance: 78.10610.L0L
PC5118 = C402H22: tolerance: 78.15224.2FL
PC5202 = C805H54: tolerance: 78.47522.51LDL
PC5305 = C402H22: tolerance: 78.22034.L1L
PC8507 PC8508 = C402H22: tolerance: 78.33134.1FLDL
PC8555 = C402H22: tolerance: 78.27224.2FLDL
PC8558-PC8560 = C402H22: tolerance: 78.47034.1FLDL
PC8602 = C402H22: tolerance: 78.33124.2FL
PD5101 = SOD323AKH40: tolerance: 083.04024.0AA1
PG4401 PG4402 PG4405 PG4406 PG4408 PG4527 PG4528 PG4530 PG4532 PG4707 PG4708 PG4808 PG4809 PG4813 PG4815 PG5001-PG5003 PG5011 PG5101-PG5114 PG5116 PG5122 PG5201-PG5212 PG5214 PG5301-PG5305 PG8605 PG8608-PG8622 = GAP-CLOSE-PWR-3: tolerance: ZZ.CLOSE.001
PG4415 PG4419 PG4422 PG4423 = GAP-CLOSE-PWR-0805-NP-5: tolerance: ZZ.PAD01.4N1
PG5223 = GAP-CLOSE-PWR: tolerance: ZZ.CLOSE.011
PL4401 = L11510030H158: tolerance: 68.2R210.20C
PL4402 = L7066-1830-UH119: tolerance: 68.4R71A.20H
PL4501 PL4502 = L7066-1830-UH119: tolerance: 68.1R510.10K
PL4701 PL4801 PL4802 = L7366-1830H119: tolerance: 068.R1510.1171
PL4702 PL4703 PL4803 PL4804 = L20125H42: tolerance: 68.00216.191
PL5001 = L7066-1830-UH119: tolerance: 68.R4710.10M
PL5101 PL5201 = L7066-1830-UH119: tolerance: 68.1R01A.20B
PL5301 PL8602 = L2520-D620H48: tolerance: 068.1R010.1281
PL8508 PL8509 = L7366-1930H158: tolerance: 68.R1510.20A
PL8603 = L4947-1115H119: tolerance: 68.1R010.20R
PQ4402 PQ4417 Q502 Q2408 Q2414 Q2505 Q2510 Q2602 Q3201 Q5701 Q6102 Q6402 Q6503 Q7201 Q7408 Q8101 Q8201 Q9202 = SOT23DGS2D4H44: tolerance: 84.2N702.J31
PQ4405 PQ4415 PQ4416 PQ4418 Q401 Q1702 Q2416 Q2417 Q4449 Q5801 Q6406 Q6504 Q7001 Q7404-Q7406 Q8705 = SOT-363H44: tolerance: 75.27002.F7C
PQ4408 = SOT23CBE2D4H46-U: tolerance: 84.T3906.I11
PR4401 = R1206H24: tolerance: 64.R0205.81L
PR4402 PR4804 PR4810 = R603H22: tolerance: 64.2R205.55L
PR4403 PR5110 = R805H24: tolerance: 63.2R231.16L
PR4404 = R402H16: tolerance: 64.40235.6DL
PR4405 = R402H16: tolerance: 64.4R705.6DL
PR4406 PR4409 PR4417 PR4474 PR4497 PR4608 PR4629 PR4821-PR4824 PR5112 PR5203 PR5305 PR5306 PR8530 PR8611 R1716 R1731 R1739 R2441 R2444 R2710 R4311 R4467 R4468 R5547 R6348 R7205 R7406 R7408 R7423-R7428 R7433 R7606 R7908 R7909 R7911 R7914 R7915 R7918 R7920 R7921 R7924 R7926 R7929 R7932 R7935 R7939 R7976-R7978 = R402H16: tolerance: 64.10035.6DL
PR4407 = R3720H40: tolerance: 64.R0105.7FL
PR4410 = R402H16: tolerance: 64.10535.60L
PR4411 PR4636 PR4658 R302 R6407 = R402H16: tolerance: 64.49905.6DL
PR4412 PR4430 PR4433 PR4462 PR4476 PR4486-PR4489 PR4498 PR5210 PR8510 PR8517 PR8520 PR8522 PR8526 PR8630 PR8634 R319 R1618 R1713 R1804 R2435 R2490 R2602 R2613 R2614 R3101 R4002 R4029 R4030 R4301 R5558 R7004 R7007 R7114 R7116 R7126-R7130 R7203 R7204 R7206 R7210 R7403 R8808 R8809 R8811 R9130 = 0R0402-PAD: tolerance: ZZ.R0402.ZZZ
PR4413 = R402H16: tolerance: 64.73215.6DL
PR4416 = R603H22: tolerance: 63.2R233.15L
PR4420 PR4441 PR4443 PR4444 PR4446 PR8572 PR8574 R7616 R8601 R8602 = R603H22: tolerance: 63.00000.00L
PR4422-PR4425 = R402H16: tolerance: 64.1R005.6DL
PR4426 = R402H16: tolerance: 64.19635.6DL
PR4427 PR4429 R1506 R1508 R1510 R1524 = R402H16: tolerance: 64.10035.L1L
PR4431 PR4473 PR4505 PR5101 R403 R1715 R1737 R2417 R2434 R2436 R2449-R2451 R2454 R2465 R2467 R2480 R2489 R2492 R2496-R2499 R2518 R2520 R2702 R2717 R3602 R3605 R3606 R4031 R4309 R4378 R4464 R5544 R5782 R5822 R5823 R6508 R7010 R7014 R7405 R7407 R7415 R7905 R7910 R7922 R8701 R8703 R8705 R8708 R8710 R9212 = R402H16: tolerance: 63.10434.1DL
PR4432 PR4450 PR5204 R1306 R2414 R2448 R4465 R5553 R5554 R7201 R7202 R7214 R7219 R7402 R7602 R7816 R7820 R7821 R7824 = R402H16: tolerance: 64.10025.6DL
PR4434 PR4437 PR4442 PR4445 PR4452 PR4453 PR4464 PR4465 PR4477 PR4480 PR4484 PR4490 PR4493 PR4671 R4466 R4469-R4471 R4481 R4482 R5821 = R402H16: tolerance: 64.R0005.6DL
PR4435 PR4472 = R402H16: tolerance: 64.10035.L3L
PR4436 PR4513 PR4514 PR5114 R1841 R2567 R5818-R5820 R7011 R7903 R8604 = R402H16: tolerance: 63.10534.1DL
PR4438 PR4463 PR4495 PR8503 PR8512 PR8513 PR8560 PR8576 R1708 R2051 R2067 R2738 R3104 R3203 R5533 R5557 R5560 R5565 R6408 R6409 R6412 R6502 R6505 R6506 R6601 R6602 R6604-R6608 R6610 R7103 R7104 R7118 R7175 R7176 R7613 R7912 R7913 R7916 R7923 R7936 R7943 R7945-R7947 R7959-R7961 R7963-R7966 R7973 R7974 R8001-R8003 R8110 R8209 R8605-R8608 R9101 R9121 R9149-R9152 R9211 = R402H16: tolerance: 63.R0034.1DL
PR4439 PR4478 PR4506 PR4507 PR4509 PR4511 PR4603 PR4615 PR4670 R4312 R7213 = R402H16: tolerance: 64.10015.6DL
PR4447 = R402H16: tolerance: 64.12735.6DL
PR4448 PR4449 R2711 R5552 R5555 R5764 R7401 R7429-R7431 = R402H16: tolerance: 64.20035.6DL
PR4451 = R402H16: tolerance: 64.95325.6DL
PR4475 = R402H16: tolerance: 64.68035.6DL
PR4485 = R402H16: tolerance: 64.18235.6DL
PR4491 = R402H16: tolerance: 64.71515.6DL
PR4492 = NTC-402H24-U: tolerance: 69.60028.031
PR4494 = R402H15: tolerance: 63.47434.L0L
PR4499 PR4613 PR4614 PR4669 PR8632 R404 R1307 R1619 R1718 R1806 R2403 R2409 R2427 R2428 R2438 R2452 R2453 R2461 R2471 R2476 R2505 R4014 R4017 R4033 R4034 R4040 R5826-R5833 R5838 R5839 R6108-R6110 R6801-R6803 R6878 R7153-R7156 R7332 R7333 = R402H15: tolerance: 63.R0034.L0L
PR4501 PR4502 PR5105 R2204 R2205 = 0R0603-PAD: tolerance: ZZ.R0603.ZZZ
PR4504 PR4516 PR4601 PR4602 PR4612 PR4647 PR4649 PR4665-PR4668 PR4701 PR4702 PR4706 PR4802 PR4806 PR4811 PR4812 PR5004 PR5117 PR5121 PR5122 PR5308 R504 R1205 R1210 R1212 R1303 R1311 R2402 R2462 R2466 R2470 R2472 R2515 R2516 R2612 R2703-R2705 R2708 R2709 R2712 R2715 R2725 R2907 R2909 R2914 R2923-R2927 R3501-R3508 R3512 R3601 R3607 R4011 R4024 R4036 R4038 R4047 R5545 R5550 R5551 R5559 R5601 R5605 R5765-R5772 R6002 R6004 R6104 R6105 R6201 R6301 = 0R0402-PAD: tolerance: ZZ.R0402.001
PR4508 PR4512 = R402H16: tolerance: 64.20035.L0L
PR4551 = R402H16: tolerance: 64.34835.6DL
PR4604 PR4607 = R402H16: tolerance: 64.10005.L1L
PR4605 = R402H16: tolerance: 64.75R05.6DL
PR4606 = R402H16: tolerance: 64.45R35.6DL
PR4609 PR4662 R1204 R1208 R1211 R1302 R1310 R8810 = R402H15: tolerance: 64.10025.L0L
PR4610 = R402H16: tolerance: 63.1R034.1DL
PR4611 PR4646 PR4650 = NTC-402H22-U: tolerance: 69.60011.201
PR4616 PR5120 = R402H16: tolerance: 64.13725.6DL
PR4617 PR4654 = NTC-402H22-U: tolerance: 069.60012.0001
PR4618 PR4643 PR4652 = R402H16: tolerance: 64.11025.6DL
PR4620 = R402H16: tolerance: 64.41205.6DL
PR4621 PR4655 = R402H16: tolerance: 64.27425.6DL
PR4622 = R402H16: tolerance: 64.10R05.L1L; signal model: Graser_PR4622
PR4623 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: Graser_PR4623
PR4624 = R402H16: tolerance: 64.49R95.L0L; signal model: Graser_PR4624
PR4625 PR4641 PR4653 = R402H16: tolerance: 64.26115.6DL
PR4626 R8806 = R402H16: tolerance: 64.33015.6DL
PR4627 PR4631 PR4639 PR4659 PR4663 PR8504 PR8505 R503 R706-R708 R807-R810 R1604 = R402H14: tolerance: 64.10005.6DL
PR4628 = R402H16: tolerance: 64.93115.6DL
PR4630 PR4638 PR4657 = R402H16: tolerance: 64.20015.L0L
PR4632 = R402H16: tolerance: 64.30105.6DL
PR4633 = R402H16: tolerance: 64.25515.6DL
PR4637 = R402H16: tolerance: 64.17815.6DL
PR4640 = R402H16: tolerance: 64.24915.L0L
PR4642 = R402H16: tolerance: 64.52305.6DL
PR4644 R7907 = R402H16: tolerance: 64.40225.6DL
PR4645 PR4651 = R402H15: tolerance: 64.10015.L3L
PR4648 = R402H16: tolerance: 64.34805.6DL
PR4656 = R402H16: tolerance: 64.28715.6DL
PR4660 = R402H16: tolerance: 64.19115.6DL
PR4661 R4377 = R402H16: tolerance: 64.84525.6DL
PR4703 PR4805 PR4814 = R1206H28: tolerance: 63.2R232.11L
PR4704 PR4803 PR4813 PR8552 = R402H16: tolerance: 64.2R205.6DL
PR4705 PR5001 PR8551 = R603H24: tolerance: 64.2R205.L0L
PR4708 PR4808 PR4816 PR5003 = R402H16: tolerance: 64.36515.6DL
PR4809 PR4815 R2908 R2910 = R402H16: tolerance: 64.10R05.L1L
PR5102 = R402H16: tolerance: 64.64915.6DL
PR5103 = R402H16: tolerance: 64.62015.6DL
PR5104 = R402H16: tolerance: 64.10225.6DL
PR5106 = R402H16: tolerance: 64.51035.6DL
PR5108 = R402H16: tolerance: 63.10034.L0L
PR5109 R7414 = R402H16: tolerance: 63.47334.1DL
PR5119 = R402H16: tolerance: 64.29425.6DL
PR5201 = R402H16: tolerance: 64.88725.6DL
PR5202 = R402H16: tolerance: 64.31615.6DL
PR5304 R7919 = R402H16: tolerance: 64.49925.6DL
PR8501 PR8502 = R805H24: tolerance: 64.2R205.16L
PR8508 = R402H16: tolerance: 64.15425.6DL
PR8553 = R402H16: tolerance: 64.49935.6DL
PR8556 PR8558 R2424 R3603 R4006 R6504 = R402H16: tolerance: 64.20025.6DL
PR8557 = R402H16: tolerance: 64.20015.6DL
PR8559 = R402H16: tolerance: 64.18025.6DL
PR8563 PR8564 R405-R407 R1606 R1617 R1701 R1707 R1714 R1717 R1721 R1726 R1738 R1817 R1820-R1827 R1910 R1911 R2007-R2010 R2041 R2043-R2047 R2053-R2055 R2059-R2066 R2068 R2111-R2119 R2415 R2426 R2430 R2443 R2491 R2514 R2607 R4009 R4303 R5556 R5564 R6114 R6115 R6403 R6411 R6415 R6511 R6609 R6611 R7006 R7189 R7216 R7603 R7614 R7818 R7901 R7902 R7917 R7927 R7931 R7933 R7944 R7948 R7949 R7952 R7953 R7975 R9119 R9148 = R402H16: tolerance: 63.10334.1DL
PR8573 = R402H16: tolerance: 64.16035.6DL
PR8613 = R402H16: tolerance: 64.34825.6DL
PR8620 = R402H16: tolerance: 64.51025.6DL
PR8626 = R402H16: tolerance: 64.12025.6DL
PR8627 R4302 = R402H16: tolerance: 64.15025.6DL
PR8633 = R603H24: tolerance: 64.R0005.55L
PT4701 PT4801 PT4803 PT8508 PT8511 PT8512 = CT7343H83: tolerance: 79.33719.20C
PT4702 PT4807 PT4808 = CT7343H79: tolerance: 077.23361.0001
PU4301 PU4302 PU4412 PU4413 U7418 = PPAK-8P-3232H36: tolerance: 84.07403.037
PU4401 = QFN32J4-G2D85H34: tolerance: 074.09538.0073
PU4403-PU4406 = PPAK-8P-3232H36: tolerance: 084.07380.0037
PU4501 = QFN20Z3-G1D1H36: tolerance: 074.08286.0043
PU4502 = QFN20Z3-G1D1H36: tolerance: 074.08288.0B43
PU4601 = QFN40J5-G3D6-DIFF-H34: tolerance: 074.95859.0D33
PU4701 PU4801 PU4802 = QFN31G5-G4P-9H34: tolerance: 074.05038.0A73
PU5001 = DFN8G2-G1710-U1H40: tolerance: 074.95808.0B73
PU5002 PU5003 = PPAK-8P-3232H36: tolerance: 084.07408.0037
PU5101 = SOIC8-G3530H63: tolerance: 074.05934.003D
PU5102 = QFN32J4-G3PH32: tolerance: 074.05388.0043
PU5201 = QFN22G4-G2PH42: tolerance: 074.02262.0043
PU5301 PU8603 = DFN8-G125065H32: tolerance: 074.05797.0073
PU8510 PU8512 PU8515 PU8516 = PPAK-8P-G5324H44-COLAY: tolerance: ZZ.00215.037
PU8514 = QFN20-G1D75H32: tolerance: 74.08812.073
PU8602 = QFN20Z3-G1H36: tolerance: 074.08288.0043
PWR1 = 196415-06031-3: tolerance: 020.K0002.0006
Q501 Q4301 Q6401 Q6501 Q7601 Q7906 = SOT23DGS2D4H44: tolerance: 084.00138.0A31
Q1701 Q7407 Q7907 Q8701-Q8704 = SOT-363H44: tolerance: 075.00138.0A7C
Q1801 = SOT-363H44: tolerance: 75.27002.F7C; signal model: Graser_Q1801
Q2507 Q6502 Q9201 = SOT23DGS2D4H44: tolerance: 084.03415.0031
Q2601 = SOT-363H44: tolerance: 75.27002.F7C; signal model: Graser_Q2601
Q2603 Q4302 = SOT23CBE2D4H46-U: tolerance: 84.T3904.K11
Q4304 = SOT323CBE2D2H40: tolerance: 84.05212.B11
Q4305 = SC70-2D2-312H44: tolerance: 84.00024.01K
Q4448 Q7401 = SOT23DGS2D4H48: tolerance: 084.02421.0031
Q5501 Q5502 = SOT23CBE2D4H44: tolerance: 84.03906.G11
Q5504 Q5505 = SOT-23-9H44: tolerance: 84.03904.I11
Q5702 = SOT-363H44: tolerance: 75.27002.F7C; signal model: Graser_Q5702
Q5703 Q6408 = SOT23CBE2D4H44: tolerance: 84.T3904.H11
Q6403-Q6405 Q6505 = SOT23CBE2D6H62: tolerance: 084.02418.0011
Q6407 = SOT-323H44: tolerance: 84.00144.K11
Q7901 = SOT-363H44: tolerance: 075.00138.0A7C; signal model: Graser_Q7901
R301 R308 R315 R1502 R1517 R1518 R1702 R1909 R2432 R2463 R2495 R2739 R2740 R2921 R2922 R3103 R3109 R4005 R6513 R6877 R7140-R7143 R7145-R7147 R7152 R7170-R7174 R8111 R8112 R8210 R8211 R9201 = R402H16: tolerance: 63.10234.1DL
R304 R305 R601 = R402H16: tolerance: 64.49R95.6DL
R309-R314 R316-R318 = R402H16: tolerance: 63.51034.1DL
R401 R1209 R1309 = R402H16: tolerance: 64.24R95.6DL
R501 R8108 R8113 R8212 R8213 = R402H16: tolerance: 64.12105.6DL
R502 = R402H16: tolerance: 64.80R65.6DL
R505 R5705 R5759 R5773-R5778 = R402H16: tolerance: 64.47005.6DL
R506 R507 R7185-R7188 = R402H16: tolerance: 64.22035.6DL
R701 = 0R0402-PAD: tolerance: ZZ.R0402.ZZZ; signal model: Graser_R701
R702 = 0R0402-PAD: tolerance: ZZ.R0402.ZZZ; signal model: Graser_R702
R703 = R402H16: tolerance: 63.22134.1DL; signal model: Graser_R703
R704 = R402H16: tolerance: 63.56034.1DL
R705 = R402H16: tolerance: 64.54R95.6DL
R811 R812 R815-R817 = GAP-CLOSE-PWR-0805-NP: tolerance: ZZ.PAD01.0N1
R1103 R1104 R2202 R2203 R2446 R2906 R2911 R6302 R6349 = 0R0603-PAD-1-U: tolerance: ZZ.00PAD.M21
R1206 R1305 = R402H16: tolerance: 64.2R005.6DL
R1215 R1312 = R402H16: tolerance: 64.24005.6DL
R1504 R1513 R1520-R1522 = R402H15: tolerance: 63.47234.L0L
R1512 R1516 R1551 R2506 R2519 R2521 R2912 R2913 R5517 R5518 R5805 R5807-R5816 R7190 R7211 R8801 = R402H16: tolerance: 63.47234.1DL
R1515 R4316 = R402H16: tolerance: 63.20334.1DL
R1554 = R402H16: tolerance: 64.20525.6DL
R1603 = R402H16: tolerance: 64.11305.6DL
R1719 R2517 R4308 = R402H16: tolerance: 64.47025.6DL
R1730 = R402H16: tolerance: 63.33434.1DL
R1803 R7803 R7804 R7806 = R402H16: tolerance: 64.60R45.6DL
R1805 = R402H16: tolerance: 64.33R05.6DL; signal model: Graser_R1805
R1815 R2504 = R402H16: tolerance: 63.10634.1DL
R1837 = R402H16: tolerance: 63.15434.1DL
R1839 R1840 R4305 R6117 = R402H16: tolerance: 63.33034.1DL
R1842 = R402H14: tolerance: 64.10R05.6DL; signal model: Graser_R1842
R1843 = R402H14: tolerance: 64.10R05.6DL; signal model: Graser_R1843
R1844 = R402H14: tolerance: 64.10R05.6DL; signal model: Graser_R1844
R1845 = R402H14: tolerance: 64.10R05.6DL; signal model: Graser_R1845
R1846 = R402H14: tolerance: 64.10R05.6DL; signal model: Graser_R1846
R1901 R2108 R7604 = R402H16: tolerance: 64.20005.6DL
R1908 = R402H16: tolerance: 64.33R05.6DL; signal model: Graser_R1908
R1912 R1913 = R402H16: tolerance: 64.33R05.6DL
R1920 = R402H16: tolerance: 64.33R05.6DL; signal model: Graser_R1920
R1921 = R402H16: tolerance: 64.33R05.6DL; signal model: Graser_R1921
R2048 R2049 R6507 = R402H16: tolerance: 63.51334.1DL
R2057 = R402H16: tolerance: 64.33R05.6DL; signal model: Graser_R2057
R2058 = R402H16: tolerance: 64.33R05.6DL; signal model: Graser_R2058
R2421 R2483 R6405 = R402H16: tolerance: 63.33134.1DL
R2437 = R402H16: tolerance: 63.43034.1DL
R2442 = R402H16: tolerance: 64.15435.6DL
R2447 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: Graser_R2447
R2455 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: Graser_R2455
R2459 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: Graser_R2459
R2460 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: Graser_R2460
R2501 = R402H16: tolerance: 64.33R05.6DL; signal model: Graser_R2501
R2502 = R402H16: tolerance: 64.33R05.6DL; signal model: Graser_R2502
R2503 = R402H16: tolerance: 64.33R05.6DL; signal model: Graser_R2503
R2507 = R402H16: tolerance: 64.33R05.6DL; signal model: Graser_R2507
R2508 = R402H16: tolerance: 64.33R05.6DL; signal model: Graser_R2508
R2509 = R402H16: tolerance: 64.33R05.6DL; signal model: Graser_R2509
R2510 = R402H16: tolerance: 64.33R05.6DL; signal model: Graser_R2510
R2511 = R402H16: tolerance: 64.33R05.6DL; signal model: Graser_R2511
R2512 = R402H16: tolerance: 64.33R05.6DL; signal model: Graser_R2512
R2513 = R402H16: tolerance: 64.33R05.6DL; signal model: Graser_R2513
R2601 R2615 R2616 = R0201H12: tolerance: 63.R003C.1IL
R2603 R2604 = R402H16: tolerance: 64.75015.6DL
R2608 = R402H16: tolerance: 64.27025.6DL
R2610 = NTC-603H38: tolerance: 69.60035.041
R2617 R2618 R4304 R5751 R5755 R5817 R5834 R7215 = R402H16: tolerance: 63.22234.1DL
R2724 = R402H16: tolerance: 63.33034.1DL; signal model: Graser_R2724
R2735 = R402H16: tolerance: 63.22234.L0L
R3102 R7601 = R402H16: tolerance: 64.24915.6DL
R3113 = R402H16: tolerance: 63.15334.1DL
R3202 = R402H16: tolerance: 63.51134.1DL
R3604 = R402H16: tolerance: 64.22125.6DL
R3610 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R3610
R3611 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R3611
R3612 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R3612
R3613 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R3613
R3614 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R3614
R3615 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R3615
R3616 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R3616
R3617 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R3617
R3618 R6124 R6125 = R805H24: tolerance: 63.R0031.16L
R4010 R4048 R7144 = R402H16: tolerance: 63.20334.L0L
R4307 = R603H22: tolerance: 63.24434.15L
R4315 = R402H16: tolerance: 64.18725.6DL
R4376 = R402H16: tolerance: 64.47035.6DL
R5501 R5502 = R603H22: tolerance: 63.R0033.L0L
R5504 R8704 R8706 R8707 R8709 = R402H14: tolerance: 63.10134.1DL
R5511 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R5511
R5512 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R5512
R5546 R5548 R6804 = R402H16: tolerance: 64.47015.6DL
R5549 R6404 R7404 R7422 R7432 = R402H16: tolerance: 64.10045.6DL
R5781 = R402H16: tolerance: 64.15035.6DL
R5804 = R402H16: tolerance: 64.49915.6DL
R5824 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R5824
R5825 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R5825
R5840 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R5840
R5841 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R5841
R5842 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R5842
R5843 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R5843
R5844 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R5844
R5845 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R5845
R5854 = R402H16: tolerance: 63.5R134.1DL; signal model: Graser_R5854
R5855 = R402H16: tolerance: 63.5R134.1DL; signal model: Graser_R5855
R5856 = R402H16: tolerance: 63.5R134.1DL; signal model: Graser_R5856
R5857 = R402H16: tolerance: 63.5R134.1DL; signal model: Graser_R5857
R5858 = R402H16: tolerance: 63.5R134.1DL; signal model: Graser_R5858
R5859 = R402H16: tolerance: 63.5R134.1DL; signal model: Graser_R5859
R5860 = R402H16: tolerance: 63.5R134.1DL; signal model: Graser_R5860
R5861 = R402H16: tolerance: 63.5R134.1DL; signal model: Graser_R5861
R6101 R6102 R8803 = R402H16: tolerance: 63.75334.1DL
R6120 = R402H16: tolerance: 63.22034.1DL; signal model: Graser_R6120
R6121 R6122 = R402H16: tolerance: 64.71525.6DL
R6123 = R402H16: tolerance: 63.22034.1DL; signal model: Graser_R6123
R6202 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R6202
R6203 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R6203
R6406 R8106 R8203 = R402H16: tolerance: 64.54905.6DL
R6410 = R402H16: tolerance: 64.42205.6DL
R6414 = R402H16: tolerance: 64.33035.6DL
R6503 = R603H22: tolerance: 63.10133.15L
R7101 R7102 = R402H15: tolerance: 63.10434.L1L
R7115 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7115
R7117 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7117
R7119 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7119
R7120 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7120
R7122 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7122
R7123 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7123
R7124 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7124
R7125 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7125
R7131 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7131
R7132 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7132
R7133 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7133
R7134 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7134
R7177 = R402H16: tolerance: 63.5R134.1DL; signal model: Graser_R7177
R7178 = R402H16: tolerance: 63.5R134.1DL; signal model: Graser_R7178
R7179 = R402H16: tolerance: 63.5R134.1DL; signal model: Graser_R7179
R7180 = R402H16: tolerance: 63.5R134.1DL; signal model: Graser_R7180
R7181 = R402H16: tolerance: 63.5R134.1DL; signal model: Graser_R7181
R7182 = R402H16: tolerance: 63.5R134.1DL; signal model: Graser_R7182
R7183 = R402H16: tolerance: 63.5R134.1DL; signal model: Graser_R7183
R7184 = R402H16: tolerance: 63.5R134.1DL; signal model: Graser_R7184
R7212 = R402H16: tolerance: 63.30334.1DL
R7217 = R402H16: tolerance: 64.90935.6DL
R7218 = R402H16: tolerance: 64.30135.6DL
R7330 R7331 = R402H16: tolerance: 64.20045.6DL
R7334 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R7334
R7335 = R402H15: tolerance: 63.R0034.L0L; signal model: Graser_R7335
R7410 = R1206H26: tolerance: 63.15132.11L
R7418 = R402H16: tolerance: 64.14325.6DL
R7805 R7807 R8101 R8102 R8206 R8208 = R402H16: tolerance: 64.40R25.6DL
R7904 = R402H16: tolerance: 63.13234.1DL
R8104 R8202 = R402H16: tolerance: 64.93105.6DL
R8107 R8204 = R402H16: tolerance: 64.13315.6DL
R8702 = R402H16: tolerance: 63.22034.L0L
R8807 = R402H16: tolerance: 63.82334.1DL
R9118 = R402H16: tolerance: 64.22015.6DL
R9132 = R402H16: tolerance: 64.49R95.6DL; signal model: Graser_R9132
R9133 = R402H16: tolerance: 64.49R95.6DL; signal model: Graser_R9133
R9138 = R402H16: tolerance: 64.49R95.6DL; signal model: Graser_R9138
R9209 = 0R0402-PAD: tolerance: ZZ.R0402.ZZZ; signal model: Graser_R9209
R9210 = 0R0402-PAD: tolerance: ZZ.R0402.ZZZ; signal model: Graser_R9210
RJ1 = 2RJ3076-078211F: tolerance: 022.10008.0551
RN401 RN1807 = ARES8-CN24-UH20: tolerance: 66.22236.A8L
RN1201 RN1301 = SMD-ARES4H18: tolerance: 66.10236.04L
RN1601 RN1704 = ARES8-CN24-MUH20: tolerance: 66.10336.08L
RN1602 = SMD-ARES4H20: tolerance: 66.R0036.04L
RN1703 RN1810 RN2601 RN6501 RN7910 = ARES2H18: tolerance: 66.10336.04L
RN1801 RN2001 = SMD-ARES4H20: tolerance: 66.20336.04L
RN1806 = ARES8-CN24-MUH20: tolerance: 66.15035.A8L; signal model: Graser_RN1806
RN1811 RN2413 RN2901 RN6503 RN7201 RN7202 RN7904 RN7905 = ARES2H16: tolerance: 66.22236.04L
RN2402 RN7901 = SMD-ARES4H18: tolerance: 66.47236.04L
RN2403 RN2404 RN2409 RN2410 RN2412 RN5502 = ARES8-CN24H20: tolerance: 66.10436.A8L
RN2405 RN2407 RN2411 = SMD-ARES4: tolerance: 66.10436.04L
RN3201 = ARES8-CN24H22: tolerance: 66.75036.08L
RN4302 RN5503 = ARES8-CN24H20: tolerance: 66.10136.A8L
RN5504 RN5505 RN6502 = SMD-ARES4H18: tolerance: 66.33036.04L
RN6401 = SMD-ARES4H18: tolerance: 66.10136.04L
RN7701 = ARES2H18: tolerance: 66.18236.04L
SPR3 SPR4 = SPR5630H142: tolerance: 34.4Y806.001
SSD1 = NFSM0-S6701-TSH4-U: tolerance: 062.10003.00X1
TP1 = 51574-0084N-W01: tolerance: 020.K0151.0008
TP4401 = TPAD28: tolerance: ZZ.PAD28.XXX
U2401 = TQFP128-2H48: tolerance: 071.01416.000G
U2402 U7302 U7601 U7602 U8801 U8804 = SC70-5-1H44: tolerance: 73.01G08.EHG
U2502 = SOT-23-5H58: tolerance: 074.00524.0B9F
U2601 = MSOP8-1H44: tolerance: 74.07718.0B9
U3101 = QFN32J4-G2D85H36: tolerance: 071.8111H.0003
U3502 = SOT-23-5H56: tolerance: 074.06288.009B
U3601 = QFN16-G1D8-UH32: tolerance: 74.02544.073; signal model: Graser_U3601
U4001 U4004 U5503 U8601 = DFN14J32-G255D95H32: tolerance: 074.02898.0093
U4002 U4003 U4006 = DFN8F3-G2517H32: tolerance: 074.05027.0093
U4007 = SC70-5H44: tolerance: 073.7SZ08.000G
U4302 = SOT-23-5H52: tolerance: 074.01004.00BF
U5501 = SOT-23-5H56: tolerance: 074.22811.009F
U5702 = SOT23-2D8-312H58: tolerance: 74.03517.07B
U5802 = QFN60J9050-G7131H32: tolerance: 71.08338.A03; signal model: Graser_U5802
U6101 = SOT-23-5H58: tolerance: 074.51712.009F
U7001 = LGA12G2H40: tolerance: 074.LNG2D.00BZ
U7101 = QFN40J4060-G2848H32: tolerance: 071.00546.0A03
U7102 = QFN20J3-G1D8H32: tolerance: 071.10224.0003; signal model: Graser_U7102
U7201 = QFN24-G2D8-UH24: tolerance: 071.04126.0D03
U7202 = DFN6G1820-G1511-UH24: tolerance: 074.02151.0A73
U7203 = DFN6F2-G1711-UH32: tolerance: 074.70933.0033
U7403 = CSP16G2D2H24: tolerance: 074.53363.M001
U7419 = CSP15G154256H24: tolerance: 074.20509.007Z
U8802 U8803 = SC70-5H44: tolerance: 73.01G32.AHH
U9103 = QFN32G5-G3D75-UH40: tolerance: 071.33203.0A03
USB1 USB2 = SKT-USB13-160146-4-U: tolerance: 022.10005.0EY1
VRAM1-VRAM4 = BGA170D1214H48: tolerance: 72.05224.A0U
WLAN1 = 40-42064-067212HF: tolerance: 062.10007.0511
WWAN1 = 04-6809-634-310-846: tolerance: 020.K0346.0034
X1801 = S-OSC3-2016H28: tolerance: 082.30006.0041
X1802 X2401 = SMD49-12H34: tolerance: 082.30003.0301
X3101 = OSC-3225-4P-4H36: tolerance: 82.30020.G61
X7901 = OSC-3225-4P-4H30: tolerance: 82.30034.641
XF3201 = XFORM12A127096H81: tolerance: 68.0NS14.301; signal model: Graser_XF3201
XF3202 = XFORM12A127096H81: tolerance: 68.0NS14.301; signal model: Graser_XF3202

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
0R0402-PAD
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
0R0603-PAD
  custom 0.254x0.254 smd: 1(0,0.66) 2(0,-0.66)
0R0603-PAD-1-U
  custom 0.254x0.254 smd: 1(0,0.66) 2(0,-0.66)
0R0805-PAD
  rect 1.549x1.346 smd: 1(0,0.838) 2(0,-0.838)
2RJ3076-078211F
  round 1.321 hole 0.914: 1(3.57,10.1) 2(2.55,11.2) 3(1.53,10.1) 4(0.51,11.2) 5(-0.51,10.1) 6(-1.53,11.2) 7(-2.55,10.1) 8(-3.57,11.2)
  oval 1.321x2.311 hole 0.61x1.6: 9(8.4,7.8) 10(-8.4,7.8) 11(8.4,0) 12(-8.4,0)
04-6809-634-310-846
  rect 0.305x0.813 smd: 1(-8.25,2.5) 2(-7.75,2.5) 3(-7.25,2.5) 4(-6.75,2.5) 5(-6.25,2.5) 6(-5.75,2.5) 7(-5.25,2.5) 8(-4.75,2.5) 9(-4.25,2.5) 10(-3.75,2.5) 11(-3.25,2.5) 12(-2.75,2.5) 13(-2.25,2.5) 14(-1.75,2.5) 15(-1.25,2.5) 16(-0.75,2.5) 17(-0.25,2.5) 18(0.25,2.5) 19(0.75,2.5) 20(1.25,2.5) 21(1.75,2.5) 22(2.25,2.5) 23(2.75,2.5) 24(3.25,2.5) 25(3.75,2.5) 26(4.25,2.5) 27(4.75,2.5) 28(5.25,2.5) 29(5.75,2.5) 30(6.25,2.5) 31(6.75,2.5) 32(7.25,2.5) 33(7.75,2.5) 34(8.25,2.5)
  rect 0.406x0.813 smd: 35(9.475,0) 36(-9.475,0)
14-00790-1A03-A
  oval 1.321x2.235 hole 0.61x1.524: 1(-4.85,8.4) 2(4.7,2.9) 3(-4.85,0.6) 4(4.7,0) 5(4.7,8.4) 6(4.7,5.65) MS(-4.85,4.3)
40-42064-067212HF
  round 0.254 hole 1.651 unplated: (-10,0)
  round 0.254 hole 1.168 unplated: (10,0)
  rect 0.305x1.549 smd: 1(9.25,-5.275) 2(9,2.275) 3(8.75,-5.275) 4(8.5,2.275) 5(8.25,-5.275) 6(8,2.275) 7(7.75,-5.275) 8(7.5,2.275) 9(7.25,-5.275) 10(7,2.275) 11(6.75,-5.275) 12(6.5,2.275) 13(6.25,-5.275) 14(6,2.275) 15(5.75,-5.275) 16(5.5,2.275) 17(5.25,-5.275) 18(5,2.275) 19(4.75,-5.275) 20(4.5,2.275) 21(4.25,-5.275) 22(4,2.275) 23(3.75,-5.275) 32(1.5,2.275) 33(1.25,-5.275) 34(1,2.275) 35(0.75,-5.275) 36(0.5,2.275) 37(0.25,-5.275) 38(0,2.275) 39(-0.25,-5.275) 40(-0.5,2.275) 41(-0.75,-5.275) 42(-1,2.275) 43(-1.25,-5.275) 44(-1.5,2.275) 45(-1.75,-5.275) 46(-2,2.275) 47(-2.25,-5.275) 48(-2.5,2.275) 49(-2.75,-5.275) 50(-3,2.275) 51(-3.25,-5.275) 52(-3.5,2.275) 53(-3.75,-5.275) 54(-4,2.275) 55(-4.25,-5.275) 56(-4.5,2.275) 57(-4.75,-5.275) 58(-5,2.275) 59(-5.25,-5.275) 60(-5.5,2.275) 61(-5.75,-5.275) 62(-6,2.275) 63(-6.25,-5.275) 64(-6.5,2.275) 65(-6.75,-5.275) 66(-7,2.275) 67(-7.25,-5.275) 68(-7.5,2.275) 69(-7.75,-5.275) 70(-8,2.275) 71(-8.25,-5.275) 72(-8.5,2.275) 73(-8.75,-5.275) 74(-9,2.275) 75(-9.25,-5.275)
  rect 1.194x2.743 smd: 76(10.35,-4.5) 77(-10.35,-4.5)
300E40-1010RA-G3
  rect 0.305x0.889 smd: 1(-9.75,2.82) 2(-9.25,2.82) 3(-8.75,2.82) 4(-8.25,2.82) 5(-7.75,2.82) 6(-7.25,2.82) 7(-6.75,2.82) 8(-6.25,2.82) 9(-5.75,2.82) 10(-5.25,2.82) 11(-4.75,2.82) 12(-4.25,2.82) 13(-3.75,2.82) 14(-3.25,2.82) 15(-2.75,2.82) 16(-2.25,2.82) 17(-1.75,2.82) 18(-1.25,2.82) 19(-0.75,2.82) 20(-0.25,2.82) 21(0.25,2.82) 22(0.75,2.82) 23(1.25,2.82) 24(1.75,2.82) 25(2.25,2.82) 26(2.75,2.82) 27(3.25,2.82) 28(3.75,2.82) 29(4.25,2.82) 30(4.75,2.82) 31(5.25,2.82) 32(5.75,2.82) 33(6.25,2.82) 34(6.75,2.82) 35(7.25,2.82) 36(7.75,2.82) 37(8.25,2.82) 38(8.75,2.82) 39(9.25,2.82) 40(9.75,2.82)
  rect 0.559x0.889 smd: 41(-10.65,2.82) 42(10.65,2.82)
  rect 1.397x1.905 smd: 43(-12.849,0) 44(12.849,0)
50224-0040N-001
  rect 0.61x1.549 smd: 1(-1.5,3.875) 2(-0.5,3.875) 3(0.5,3.875) 4(1.5,3.875)
  rect 1.194x1.803 smd: 5(-2.797,0) 6(2.797,0)
50224-0080N-W02-U
  rect 0.406x1.549 smd: 1(-3.5,3.875) 2(-2.5,3.875) 3(-1.5,3.875) 4(-0.5,3.875) 5(0.5,3.875) 6(1.5,3.875) 7(2.5,3.875) 8(3.5,3.875)
  rect 1.194x1.803 smd: 9(-4.797,0) 10(4.797,0)
50406-02071-W01
  rect 0.305x1.295 smd: 1(-4.75,-1.95) 2(-4.25,-1.95) 3(-3.75,-1.95) 4(-3.25,-1.95) 5(-2.75,-1.95) 6(-2.25,-1.95) 7(-1.75,-1.95) 8(-1.25,-1.95) 9(-0.75,-1.95) 10(-0.25,-1.95) 11(0.25,-1.95) 12(0.75,-1.95) 13(1.25,-1.95) 14(1.75,-1.95) 15(2.25,-1.95) 16(2.75,-1.95) 17(3.25,-1.95) 18(3.75,-1.95) 19(4.25,-1.95) 20(4.75,-1.95)
  rect 1.194x2.692 smd: 21(-7.15,0) 24(7.15,0)
  rect 2.311x1.295 smd: 22(-3.9,1.95) 23(3.9,1.95)
50552-01601-001
  rect 0.406x1.549 smd: 1(-3.75,1.173) 2(-3.25,-1.173) 3(-2.75,1.173) 4(-2.25,-1.173) 5(-1.75,1.173) 6(-1.25,-1.173) 7(-0.75,1.173) 8(-0.25,-1.173) 9(0.25,1.173) 10(0.75,-1.173) 11(1.25,1.173) 12(1.75,-1.173) 13(2.25,1.173) 14(2.75,-1.173) 15(3.25,1.173) 16(3.75,-1.173)
  rect 1.397x2.896 smd: 17(-5.45,0) 18(5.45,0)
50696-00601-001
  rect 0.305x0.813 smd: 1(1.25,2.5) 2(0.75,2.5) 3(0.25,2.5) 4(-0.25,2.5) 5(-0.75,2.5) 6(-1.25,2.5)
  rect 0.406x0.813 smd: 7(2.25,0) 8(-2.25,0)
50698-00401-W01-U
  rect 0.305x1.6 smd: 1(1.5,5.2) 2(0.5,5.2) 3(-0.5,5.2) 4(-1.5,5.2)
  rect 1.803x2.007 smd: 5(4.21,0) 6(-4.21,0)
50699-03001-W01
  rect 0.229x0.813 smd: 1(-11.6,3.3) 2(-10.8,3.3) 3(-10,3.3) 4(-9.2,3.3) 5(-8.4,3.3) 6(-7.6,3.3) 7(-6.8,3.3) 8(-6,3.3) 9(-5.2,3.3) 10(-4.4,3.3) 11(-3.6,3.3) 12(-2.8,3.3) 13(-2,3.3) 14(-1.2,3.3) 15(-0.4,3.3) 16(0.4,3.3) 17(1.2,3.3) 18(2,3.3) 19(2.8,3.3) 20(3.6,3.3) 21(4.4,3.3) 22(5.2,3.3) 23(6,3.3) 24(6.8,3.3) 25(7.6,3.3) 26(8.4,3.3) 27(9.2,3.3) 28(10,3.3) 29(10.8,3.3) 30(11.6,3.3)
  rect 0.559x1.295 smd: 31(-13.075,0) 32(13.075,0)
51530-02001-W01-U
  rect 0.305x0.838 smd: 1(-4.75,3.175) 2(-4.25,3.175) 3(-3.75,3.175) 4(-3.25,3.175) 5(-2.75,3.175) 6(-2.25,3.175) 7(-1.75,3.175) 8(-1.25,3.175) 9(-0.75,3.175) 10(-0.25,3.175) 11(0.25,3.175) 12(0.75,3.175) 13(1.25,3.175) 14(1.75,3.175) 15(2.25,3.175) 16(2.75,3.175) 17(3.25,3.175) 18(3.75,3.175) 19(4.25,3.175) 20(4.75,3.175)
  rect 0.813x2.007 smd: 21(-6.45,0) 22(6.45,0)
51574-0084N-W01
  rect 0.305x1.194 smd: 1(-3.5,3.3) 2(-2.5,3.3) 3(-1.5,3.3) 4(-0.5,3.3) 5(0.5,3.3) 6(1.5,3.3) 7(2.5,3.3) 8(3.5,3.3)
  rect 0.406x0.813 smd: 9(-5.185,0) 10(5.185,0)
87212-1400N
  rect 0.61x1.549 smd: 1(-6.5,-2.525) 2(-5.5,-2.525) 3(-4.5,-2.525) 4(-3.5,-2.525) 5(-2.5,-2.525) 6(-1.5,-2.525) 7(-0.5,-2.525) 8(0.5,-2.525) 9(1.5,-2.525) 10(2.5,-2.525) 11(3.5,-2.525) 12(4.5,-2.525) 13(5.5,-2.525) 14(6.5,-2.525)
  rect 1.194x1.803 smd: 15(-7.797,0) 16(7.797,0)
88231-1001-LP
  rect 0.813x1.905 smd: 1(-5.625,4.878) 2(-4.375,4.878) 3(-3.125,4.878) 4(-1.875,4.878) 5(-0.625,4.878) 6(0.625,4.878) 7(1.875,4.878) 8(3.125,4.878) 9(4.375,4.878) 10(5.625,4.878)
  rect 1.295x3.353 smd: 11(-8.473,0) 12(8.473,0)
196415-06031-3
  rect 0.305x0.838 smd: 1(-1.25,3.175) 2(-0.75,3.175) 3(-0.25,3.175) 4(0.25,3.175) 5(0.75,3.175) 6(1.25,3.175)
  rect 0.813x2.007 smd: 7(-2.95,0) 8(2.95,0)
ADDR0206-P013A-1-U
  round 0.254 hole 1.6 unplated: (-34.4,0)
  round 0.254 hole 1.118 unplated: (34.4,0)
  custom 0.089x0.089 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 261(-33.8,-12) 262(33.8,-12)
