# Allegro board 17931-1.1228WZS1336.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TOUCH_USB20_P: length 171.2
  TOP w0.114: v2(110.18,102.82) 110.42,102.82 v1(110.7,102.54) ; v3(214.38,47.73) 214.07,47.42 213.78,47.42 R5512.1
  L5 w0.102: v3(214.38,47.73) 214.63,47.47 215.32,47.47 215.45,47.6 215.45,49.99 219.13,53.67 219.89,53.67 221.03,54.81 221.03,58.6 220.25,59.39 218,59.39 216.4,60.99 207.32,60.99 205.84,59.51 191.62,59.51 190,57.89 182.77,57.89 178.59,62.07 178.59,62.09 177.5,63.19 177.5,63.8 175.28,66.02 172.31,66.02 170.89,67.44 160.07,67.44 159.91,67.6 131.75,67.6 125.63,73.71 125.63,93.21 122.63,96.21 122.63,101.4 122.44,101.59 122.44,101.89 119.74,104.6 117.13,104.6 115.98,105.75 115.98,107.13 v2(115.79,107.32)
  L6 w0.102: v2(110.18,102.82) 109.76,103.24 109.76,104.75 111.47,106.47 112.46,106.47 113.51,107.52 114.63,107.52 115.41,106.74 115.66,106.74 115.79,106.87 v2(115.79,107.32)
  BOTTOM w0.114: CPU1.CH6 109.86,103.14 v2(110.18,102.82)
TOUCH_USB20_P_R: length 14.3
  TOP w0.114: R5512.2 212.39,47.42 210.96,47.42 v2(210.74,47.64) 210.5,47.88 v1(210.24,47.88)
  BOTTOM w0.114: v2(210.74,47.64) 210.86,47.52 212.22,47.52 212.37,47.68 213.57,47.68 213.9,47.35 213.9,46.66 214.02,46.53 214.72,46.53 ED5502.3 215.82,46.79 216.3,46.79 216.97,46.12 216.97,44.78 217.84,43.91 218.15,43.91 218.28,44.05 LCD1.27
TP_EN#: length 151.1
  TOP w0.089: U2401.49 31.55,61.9 29.98,63.48 v2(29.62,63.48) ; v2(94.75,28.6) 95.56,29.41 98.48,29.41 98.71,29.64 98.71,30.63 98.81,30.74 98.81,31.57 99.13,31.88 99.85,31.88 v1(100.97,33) 103.33,35.36 103.33,37.36 102.49,38.2 v2(102.49,39.45)
  L5 w0.089: v2(29.62,63.48) 28.76,62.61 28.76,59.75 26.06,57.05 25.41,57.05 24.97,56.61 24.97,55.92 23.49,54.44 23.49,53.18 22.56,52.25 22.56,50.79 22.14,50.36 22.14,47.3 21.61,46.77 21.31,46.47 21.31,33.19 22.04,32.47 26.19,32.47 27.27,33.56 27.5,33.79 27.5,34.42 27.5,34.57 28.06,35.12 33.16,35.12 34.14,36.1 34.22,36.1 35.82,37.69 35.82,38.61 39.46,42.26 52.82,42.26 54.99,40.09 59.44,40.09 60.77,38.76 62.84,38.76 64.28,37.32 76.31,37.32 78.13,39.14 93.1,39.14 93.54,39.58 96.72,39.58 97.33,38.97 99.88,38.97 100.73,39.82 102.12,39.82 v2(102.49,39.45)
  BOTTOM w0.089: R2499.2 94.01,31.12 R6504.1 93.6,30.56 93.6,29.49 94.49,28.6 v2(94.75,28.6)
TP_ON#_GATE: length 9
  BOTTOM w0.089: Q6503.G 97.8,27.81 97.24,28.36 96.26,28.36 95.71,27.81 Q6502.G 94.77,27.81 94.11,28.47 94.11,28.7 93.25,29.57 v1(93.25,30.15) 93.25,31.01 R6504.2 93.22,31.73 C6502.2
TP_VDD: length 2.4
  BOTTOM w0.305: R6511.2 103.2,36.5 TP1.8 v2(103.2,34.44)
  vias: v2(95.48,28.6)
TP_WAKE_KBC#: length 307.6
  TOP w0.089: v2(161.04,58.17) 159.43,59.77 156.71,59.77 154.36,62.12 154.36,65.57 150.97,68.96 146.15,68.96 145.65,69.46 v2(145.65,69.5) ; v2(24.45,59.6) 24.45,59.6 24.97,59.6 25.15,59.41 U2401.33 ; AFTP6525.1 106.45,37.21 105.62,37.21 105.41,37.01 105.01,37.01 v2(104.47,37.54)
  L5 w0.089: v2(104.47,37.54) 104.17,37.84 102.23,37.84 101.26,36.88 97.52,36.88 97.41,36.98 96.62,37.77 96.55,37.77 96.07,38.25 94.38,38.25 93.37,37.24 86.97,37.24 86.87,37.34 83.09,37.34 82.4,36.65 76.78,36.65 75.96,35.83 54.02,35.83 54.01,35.82 53.59,35.82 53.37,36.04 52.25,36.04 51.87,35.66 51.87,34.29 51.64,34.06 37.52,34.06 36.79,34.79 36.68,34.89 34.64,34.89 31.68,31.93 28.88,31.93 26.29,29.34 22.72,29.34 19.75,32.31 19.75,35.73 18.49,36.99 18.49,49.35 19.28,50.15 19.28,55.17 23.22,59.11 23.95,59.11 v2(24.45,59.6) ; v2(161.04,58.17) 161.04,58.12 161.42,57.74 162.71,57.74 163.38,58.4 163.38,59.16 163.78,59.56 164.56,59.56 164.7,59.7 166.21,59.7 166.22,59.71 166.78,59.71 168.46,58.03 168.46,53.65 170.41,51.71 170.41,44.51 170.41,44.02 169.7,43.31 168.85,43.31 168.85,43.31 168.66,43.31 168.65,43.31 168.46,43.31 168.17,43.31 133.48,43.31 132.2,44.59 132.2,44.62 131.58,45.24 131.55,45.24 130.98,45.8 110.83,45.8 109.95,44.93 109.93,44.93 109.9,44.89 109.89,44.89 109.73,44.73 104.6,44.73 v2(104.46,44.59)
  BOTTOM w0.089: v2(104.46,44.59) 104.46,43.04 105.09,42.41 105.09,41.53 105.67,40.95 105.67,38.28 107.2,36.75 TP1.4 107.2,33.7 107.62,33.28 107.62,32.9 107.37,32.65 105.38,32.65 104.73,33.3 104.73,36.35 R6511.1 104.32,37.39 v2(104.47,37.54) ; v2(145.65,69.5) 145.65,69.56 144.7,70.51 136.82,70.51 135.99,69.69 135.99,69.29 135.32,68.62 132.61,68.62 132.37,68.86 119.78,68.86 117.16,71.48 114.77,71.48 111.99,71.48 106.73,76.74 R319.1
TPAN_VDD_EN_R: length 5.1
  TOP w0.089: v1(155.65,107.94) R5560.2 155.47,106.55 155.62,106.4 v2(155.86,106.4) 156.39,105.87 R5559.2 R5564.1
  BOTTOM w0.089: v2(155.86,106.4) 155.86,106.14 156.22,105.79 U5503.5
TPCLK_C: length 2.8
  TOP w0.114: AFTP6530.1 110.62,33.96 v2(110.01,34.57) 110.06,34.62 RN6502.4
  BOTTOM w0.114: v2(110.01,34.57) 110.2,34.76 TP1.1
TPDATA_C: length 3.8
  TOP w0.114: AFTP6524.1 109.22,33.83 109.48,34.09 109.53,34.09 v2(109.54,34.1) 109.41,34.23 RN6502.3
  BOTTOM w0.114: TP1.2 109.2,34.44 v2(109.54,34.1)
TPM_GPIO0: length 2.2
  TOP w0.089: R9121.1 167.14,81.1 167.14,81.59 167,81.72 v1(166.9,81.72) 166.79,81.72 166.21,81.15 U9103.29
TPM_GPIO1: length 2
  TOP w0.089: U9103.30 166.32,81.65 167.01,82.33 TP9102.1
TPM_GPIO4: length 2
  TOP w0.089: v1(159.31,80.62) 159.54,80.39 R9118.1 160.26,80.39 160.52,80.65 U9103.13
TPM_ID: length 84.3
  TOP w0.089: R1910.2 150.53,73.64 R1911.1 150.53,70.09 154.71,65.9 154.71,62.71 v1(155.96,61.47) 156.92,60.5 v2(156.92,60.41)
  L5 w0.089: v2(156.92,60.41) 126.48,60.41 121.82,65.07 121.82,66.8 112.15,76.47 112.15,80.14 112.86,80.85 112.86,83.82 112.33,84.35 112.33,89.49 v2(111.1,90.72)
  BOTTOM w0.089: CPU1.CK25 v2(111.1,90.72)
TPM_SPI_IRQ#: length 94
  TOP w0.089: v2(160.24,62.94) 160.4,63.11 v1(160.4,68.61) 160.4,69.09 160.05,69.44 160.05,72.28 159.14,73.19 159.14,74.64 R9151.2
  L5 w0.089: v2(160.24,62.94) 159.81,63.37 159.08,63.37 158.95,63.24 130.57,63.24 125.53,68.28 125.08,68.28 118.2,75.16 118.2,82.04 117.38,82.85 117.38,84.69 120.23,87.54 120.23,89.1 120.02,89.3 120.02,89.89 118.61,91.31 118.61,94.35 117.09,95.87 113.04,95.87 111.46,94.29 109.65,94.29 109.49,94.45 108.45,94.45 v2(107.99,93.99)
  BOTTOM w0.089: v2(107.99,93.99) 107.99,93.99 108.03,94.03 108.04,94.03 CPU1.CF20
TPS2544_FAULT#: length 8
  TOP w0.089: R3607.1 v1(21.86,44.72) 22.15,45.01 22.15,47.68 23.02,48.54 23.02,50.18 U3601.13
TPS70933_EN: length 12.9
  TOP w0.089: Q7201.D 57.45,131.96 56.42,133 R7218.1 55.63,132.89 52.3,132.89 49.66,130.25 v1(48.34,130.25) 48.34,129.64 R7217.2 48.61,129.36 49.12,129.36 U7203.4
TPS70933_EN_G: length 2.8
  TOP w0.089: R7216.2 v1(57.97,135.21) C7215.2 58.75,134.22 Q7201.G
TS#_DIMM0_1: length 3.8
  TOP w0.114: v1(63.4,44.83) v2(64.03,45.13) 64.68,45.13 R1215.2
  BOTTOM w0.114: v2(64.03,45.13) 63.58,44.68 DM1.134
TS#_DIMM1_1: length 4.2
  TOP w0.114: v1(141.84,45.44) 140.95,45.39 140.51,45.39 v2(140.13,45.02)
  BOTTOM w0.114: v2(140.13,45.02) 139.99,45.02 139.78,44.8 DM2.134
TS_INT#: length 205.6
  TOP w0.089: R5533.2 113.52,104.19 115.01,104.19 115.42,104.6 v2(115.42,105.06) ; AFTP5502.1 170.81,34.44 v2(170.15,33.78)
  L5 w0.089: v2(170.15,33.78) 170.17,33.81 184.23,33.81 185.65,35.23 186.19,35.23 190.38,39.42 192.51,39.42 193.3,38.63 199.12,38.63 199.5,38.25 203.18,38.25 203.18,38.26 204.44,38.26 205.15,37.55 208,37.55 208.68,38.22 211.51,38.22 213.3,40.01 216.28,40.01 219.32,36.96 220.7,36.96 221.15,37.42 221.15,50.07 v2(220.22,51)
  L6 w0.089: v2(115.42,105.06) 115.57,104.92 119.62,104.92 122.55,101.98 122.55,98.04 122.28,97.77 122.28,91.35 123.7,89.93 123.7,81.74 123.5,81.54 123.5,72.29 126.27,69.52 128.29,69.52 130.98,66.83 158.78,66.83 159.83,65.78 169.27,65.78 169.9,65.15 170.58,65.15 170.65,65.22 171.94,65.22 172,65.17 175.5,65.17 176.56,64.11 176.56,58.49 177.65,57.41 177.65,55.67 177.44,55.46 177.44,40.15 171.07,33.78 v2(170.15,33.78)
  BOTTOM w0.089: LCD1.13 220.18,51.05 v2(220.22,51)
TS_VREF: length 4.5
  BOTTOM w0.089: TP7701.1 117.15,129.31 117.3,129.46 118.23,129.46 119.19,130.42 119.19,130.98 119.63,131.41 GPU1.AE2
TYPEC_DCIN1_EN#: length 75.2
  TOP w0.089: R2491.1 37.65,56.34 37.65,57.33 37.15,57.82 U2401.63 37.15,59.39 34.48,62.07 34.48,65.4 36.7,67.63 36.7,69.36 v2(36.27,69.79) ; Q7406.2 29.82,110.34 29.7,110.47 29.15,110.47 v2(28.96,110.66) 29.12,110.82 29.52,110.82 30.65,111.96 v1(30.65,112.42) 30.65,113.42 R7428.1 30.48,113.87 29.98,114.38 29.98,115.11 29.85,115.24 Q7407.2
  L3 w0.089: v2(28.96,110.66) 29.01,110.66 29.07,110.59 29.31,110.59 29.44,110.47 29.44,104.01 29.03,103.6 29.03,102.24 33.81,97.46 34.96,97.46 38.43,93.99 39.72,93.99 41.33,92.38 41.33,80.52 41.84,80.01 41.84,77.19 39.96,75.31 39.96,73.54 38.2,71.78 37.71,71.78 36.27,70.34 v2(36.27,69.79)
TYPEC_DP_AUXN: length 42.9
  TOP w0.114: v2(61.09,115.15) 60.79,115.53 58.72,117.6 57.1,117.6 56.27,118.43 U5802.27 ; R7104.1 28.12,113.36 v2(28.71,113.36)
  L6 w0.102: v2(61.09,115.15) 61.09,115.81 60.84,116.05 57.95,116.05 57.26,116.74 45.59,116.74 44.88,116.03 41.29,116.03 40.27,115.01 35.06,115.01 34.03,113.98 31.66,113.98 31.04,113.36 v2(28.71,113.36)
TYPEC_DP_AUXP: length 43
  TOP w0.114: R7103.1 28.39,112.87 28.57,112.87 28.72,112.72 v2(28.72,112.72) ; U5802.26 55.44,118.03 55.61,118.2 56.17,118.2 57,117.37 58.62,117.37 60.56,115.44 60.56,115.26 v2(60.45,115.15)
  L6 w0.102: v2(60.45,115.15) 60.88,115.58 60.88,115.72 60.76,115.85 57.86,115.85 57.18,116.54 45.67,116.54 44.96,115.83 41.37,115.83 40.35,114.81 35.15,114.81 34.12,113.78 31.75,113.78 31.12,113.15 29.4,113.15 29.27,113.03 29.27,112.69 29.14,112.56 28.88,112.56 v2(28.72,112.72)
TYPEC_DP_N0: length 38.9
  TOP w0.114: C7113.1 28.23,103.73 v2(28.27,103.78) ; v2(46.47,122.28) 46.68,122.07 46.89,122.07 47.2,121.75 47.2,120.86 47.3,120.77 U5802.49
  L5 w0.102: v2(46.47,122.28) 46.36,122.17 45.91,122.17 45.49,121.74 43.34,121.74 41.66,123.42 37.54,123.42 35.63,121.51 34.69,121.51 33.61,120.43 33.61,119.08 33.91,118.77 33.91,112.68 32.35,111.11 32.35,109.8 32.98,109.16 32.98,106.54 30.82,104.37 29.56,104.37 28.94,103.76 28.29,103.76 v2(28.27,103.78)
TYPEC_DP_N0_C: length 0.7
  TOP w0.114: C7113.2 26.69,103.6 26.32,103.6 R7178.1
TYPEC_DP_N1: length 44.5
  TOP w0.114: v2(47.69,122.25) 47.88,122.25 48.42,121.72 48.42,120.67 48.5,120.58 U5802.46 ; C7107.1 27.93,105.07 28.11,105.07 v2(28.27,105.23)
  L5 w0.102: v2(28.27,105.23) 28.49,105.01 29.99,105.01 30.61,105.62 30.61,112.8 31.3,113.49 31.3,115.28 31.08,115.5 30.41,115.5 29.95,115.95 29.95,121.39 30.69,122.12 30.69,123.39 30.99,123.7 35.53,123.7 35.86,124.03 41.91,124.03 43.59,122.35 45.08,122.35 45.87,123.14 46.9,123.14 47.14,122.9 47.14,122.15 47.27,122.03 47.47,122.03 v2(47.69,122.25)
TYPEC_DP_N1_C: length 0.8
  TOP w0.114: R7180.1 26.39,105.06 26.57,105.06 C7107.2
TYPEC_DP_N2: length 44.7
  TOP w0.114: U5802.44 49.3,120.77 49.25,120.81 49.25,121.87 48.47,122.66 48.47,123.77 48.17,124.07 47.73,124.07 v2(47.65,124.16) ; C7108.1 v2(28.31,106.58)
  L5 w0.102: v2(47.65,124.16) 47.39,123.9 45.99,123.9 44.69,125.2 36.12,125.2 35.23,124.31 30.69,124.31 30.36,124.64 29.66,124.64 29.11,124.09 29.11,121.82 29.34,121.59 29.34,115.34 30,114.68 30,107.27 29.18,106.45 28.44,106.45 v2(28.31,106.58)
TYPEC_DP_N2_C: length 0.7
  TOP w0.114: R7182.1 26.81,106.85 C7108.2
TYPEC_DP_N3: length 45.3
  TOP w0.114: U5802.41 50.5,120.77 50.45,120.82 50.45,121.9 49.95,122.4 v2(49.74,122.4) ; v2(28.25,108.51) 28.17,108.43 C7110.1
  L5 w0.102: v2(28.25,108.51) 28.35,108.41 29.26,108.41 29.39,108.54 29.39,114.43 28.73,115.09 28.73,121.31 28.5,121.54 28.5,124.34 29.41,125.25 30.64,125.25 30.94,124.94 34.87,124.94 35.73,125.81 47.13,125.81 48.44,124.49 48.44,122.59 48.68,122.35 49.69,122.35 v2(49.74,122.4)
TYPEC_DP_N3_C: length 0.6
  TOP w0.114: C7110.2 R7184.1
TYPEC_DP_P0: length 38.9
  TOP w0.114: v2(28.27,103.1) 28.15,102.97 C7112.1 ; v2(46.47,121.64) 46.67,121.84 46.79,121.84 46.97,121.66 46.97,120.84 46.9,120.77 U5802.50
  L5 w0.102: v2(46.47,121.64) 46.33,121.85 46.29,121.85 46.17,121.96 45.99,121.96 45.57,121.54 43.25,121.54 41.58,123.22 37.62,123.22 35.72,121.31 34.78,121.31 33.81,120.35 33.81,119.16 34.12,118.86 34.12,112.59 32.55,111.02 32.55,109.89 33.19,109.25 33.19,106.45 30.9,104.17 29.64,104.17 29.03,103.56 28.69,103.56 28.28,103.17 v2(28.27,103.1)
TYPEC_DP_P0_C: length 0.6
  TOP w0.114: R7177.1 C7112.2
TYPEC_DP_P1: length 43.9
  TOP w0.114: C7114.1 v2(28.27,104.6) ; U5802.47 48.1,120.59 48.19,120.68 48.19,121.62 48.03,121.78 47.85,121.78 v2(47.69,121.62)
  L5 w0.102: v2(47.69,121.62) 47.48,121.82 47.19,121.82 46.94,122.07 46.94,122.82 46.82,122.94 45.95,122.94 45.16,122.15 43.51,122.15 41.83,123.83 35.94,123.83 35.61,123.5 31.08,123.5 30.89,123.31 30.89,122.04 30.15,121.3 30.15,116.04 30.49,115.7 31.17,115.7 31.5,115.37 31.5,113.4 30.81,112.72 30.81,105.54 30.08,104.8 28.47,104.8 v2(28.27,104.6)
TYPEC_DP_P1_C: length 0.6
  TOP w0.114: R7179.1 C7114.2
TYPEC_DP_P2: length 44.8
  TOP w0.114: v2(28.31,105.94) 28.05,106.2 27.87,106.2 C7109.1 ; U5802.45 48.9,120.7 49.03,120.82 49.03,121.78 48.24,122.56 48.24,123.68 48.1,123.82 47.95,123.82 v2(47.65,123.52)
  L5 w0.102: v2(47.65,123.52) 47.65,123.45 47.52,123.33 47.34,123.33 46.97,123.7 45.9,123.7 44.61,124.99 36.21,124.99 35.32,124.11 30.6,124.11 30.27,124.44 29.75,124.44 29.31,124.01 29.31,121.9 29.54,121.68 29.54,115.43 30.2,114.77 30.2,107.19 29.26,106.25 28.62,106.25 v2(28.31,105.94)
TYPEC_DP_P2_C: length 0.8
  TOP w0.114: R7181.1 26.41,106.3 26.6,106.3 C7109.2
TYPEC_DP_P3: length 45.3
  TOP w0.114: C7111.1 28.02,107.65 v2(28.25,107.88) ; U5802.42 50.1,120.77 50.22,120.88 50.22,121.81 50.05,121.97 49.89,121.97 49.74,121.82 v2(49.74,121.77)
  L5 w0.102: v2(28.25,107.88) 28.24,107.88 28.57,108.21 29.35,108.21 29.59,108.45 29.59,114.51 28.93,115.17 28.93,121.4 28.71,121.62 28.71,124.26 29.49,125.05 30.55,125.05 30.86,124.74 34.95,124.74 35.82,125.6 47.04,125.6 48.24,124.41 48.24,122.51 48.59,122.15 49.35,122.15 v2(49.74,121.77)
TYPEC_DP_P3_C: length 0.8
  TOP w0.114: R7183.1 26.39,107.87 26.57,107.87 C7111.2
TYPEC_SMBCLK: length 67.1
  TOP w0.114: U7102.3 33.04,116.39 33.37,116.07 33.74,116.07 33.88,115.93 RN2413.4 33.88,115.19 33.25,114.56 33.25,114.08 32.61,113.44 32.61,112.35 33.39,111.58 33.39,111.05 33.69,110.75 v2(33.75,110.75) ; v2(33.75,110.75) Q2417.1 ; v2(33.75,110.75) 33.19,110.19 v1(32.85,110.19) ; v2(31.46,71.38) 32.64,70.2 33.48,70.2 33.88,70.6 33.88,70.61 34.42,71.15 37.36,71.15 38.01,70.49 U2401.91
  L5 w0.114: v2(31.46,71.38) 31.46,72.02 33.35,73.92 36.35,73.92 39.87,77.44 39.87,92.3 38.53,93.65 38.53,99.35 37.37,100.51 37.37,107.09 36.98,107.47 36.98,108.74 35.63,110.1 35.63,110.79 35.23,111.18 34.19,111.18 v2(33.75,110.75)
TYPEC_SMBDA: length 64.6
  TOP w0.114: v2(31.49,70.07) 31.81,69.74 33.67,69.74 34.33,70.41 34.33,70.42 34.61,70.69 37.17,70.69 38.16,69.69 U2401.89 ; v2(35.61,111.48) 35.61,112.05 35.05,112.61 Q2417.4 35.05,113.84 35.57,114.36 v1(35.57,114.71) 35.57,114.95 35.27,115.25 34.55,115.25 ; 34.55,115.25 RN2413.3 ; 34.55,115.25 34.55,115.92 34.04,116.43 33.56,116.43 33.44,116.56 U7102.4
  L5 w0.114: v2(35.61,111.48) 35.97,111.12 35.97,110.24 37.32,108.88 37.32,107.61 38.29,106.65 38.29,103.75 38.18,103.64 38.18,100.21 38.77,99.62 38.77,94.56 40.12,93.21 40.12,77.34 36.35,73.57 33.49,73.57 31.96,72.04 31.96,70.54 v2(31.49,70.07)
U9101_2_GND: length 2.1
  TOP w0.305: U9103.2 164.74,83.85 164.65,83.95 R9101.2 164.93,84.66 v1(165.51,84.66)
UART_2_CRXD_DTXD: length 204.7
  TOP w0.114: v2(28.78,23.4) 28.55,23.4 28.06,23.9 28.06,27.19 30.86,29.99 30.91,29.99 32.05,31.13 32.05,33.53 36.09,37.58 36.09,37.96 39.24,41.11 41.9,41.11 42.59,41.8 47.01,41.8 v1(48.24,43.03) 48.64,43.03 50.04,44.43 50.04,50.37 56.27,56.61 98.47,56.61 98.72,56.35 108.69,56.35 123.97,71.63 123.97,89.29 121.92,91.34 121.92,93.57 118.72,96.77 118.72,98.3 117.78,99.24 117.72,99.24 117.25,99.71 v2(117.25,99.71) 117.1,99.56 R2048.2 ; R6803.1 26.83,45.6 26.83,41.48 25.79,40.45 25.79,36.9 25.54,36.65 22.56,36.65 21.29,35.37 21.29,33.56 18.23,30.49 16.41,30.49 15.2,29.28 15.2,24.78 v2(14.23,23.8)
  L6 w0.114: v2(28.78,23.4) 28.5,23.68 21.14,23.68 20.88,23.41 14.61,23.41 v2(14.23,23.8)
  BOTTOM w0.076: CPU1.CR12 114.21,99.56 114.66,99.11 115.14,99.11
  BOTTOM w0.114: 115.14,99.11 116.65,99.11 v2(117.25,99.71)
UART_2_CRXD_DTXD_CON: length 10.5
  TOP w0.114: DBG1.14 28.61,50.77 30.73,48.65 30.73,46.43 30.63,46.33 30.63,46.33 30.36,46.06 30.36,45.34 29.78,44.76 v1(29.59,44.76) 29.34,44.76 28.32,45.77 R6803.2
UART_2_CTXD_DRXD: length 215.3
  TOP w0.114: R6802.1 30.66,44.12 29.58,44.12 28.47,45.24 27.6,45.24 27.36,45 27.08,44.72 27.08,41.3 26.04,40.26 26.04,36.8 25.64,36.41 22.66,36.41 21.54,35.29 21.54,33.47 18.33,30.25 16.51,30.25 15.45,29.18 15.45,24 v2(14.35,22.91) ; R2049.2 114.81,99.32 115.69,100.2 117.17,100.2 117.22,100.15 117.43,100.15 v2(117.88,99.7) 118.08,99.5 118.08,99.49 118.96,98.61 118.96,96.87 122.33,93.5 122.33,91.35 124.21,89.47 124.21,71.53 108.79,56.11 98.61,56.11 98.35,56.36 56.37,56.36 50.28,50.27 50.28,44.3 47.74,41.76 v1(47.63,41.76) 47.43,41.56 42.69,41.56 42,40.87 39.34,40.87 36.34,37.86 36.34,37.48 32.29,33.43 32.29,31.03 31.01,29.75 30.96,29.75 28.3,27.09 28.3,24 28.42,23.88 28.98,23.88 v2(29.44,23.42)
  L6 w0.114: v2(29.44,23.42) 29.44,23.39 29.06,23.01 29.01,23.01 28.96,22.97 28.84,22.97 27.82,21.95 24.85,21.95 23.57,23.23 21,23.23 20.95,23.18 14.62,23.18 v2(14.35,22.91)
  BOTTOM w0.076: CPU1.CP12 113.15,99.56 113.38,99.33 113.41,99.32 113.42,99.31 113.7,99.31 113.71,99.32 114.23,99.32 114.66,98.88 114.99,98.88
  BOTTOM w0.114: v2(117.88,99.7) 117.07,98.88 116.94,98.88 116.93,98.88 116.63,98.88 116.63,98.88 114.99,98.88
UART_2_CTXD_DRXD_CON: length 7
  TOP w0.114: R6802.2 v1(30.99,46.18) 31.04,46.23 31.04,49.17 29.61,50.61 DBG1.13
USB1_SBU1: length 37
  TOP w0.114: 16.03,112.47 AFTP7101.1 ; 16.03,112.47 16.03,113.44 15.91,113.56 15.78,113.69 15.78,115.82 16.03,116.07 16.03,116.71 16.16,116.84 16.16,119.19 16.39,119.41 16.84,119.86 17.63,119.86 17.91,120.14 17.91,121.25 17.75,121.41 17.14,121.41 17.02,121.29 ED7307.2 16.27,120.56 16.06,120.78 v2(16.06,121.29) ; 16.03,112.47 16.03,110.96 16.91,110.07 17.19,110.07 R7331.2 17.73,110.08 20.51,110.08 21.1,109.5 21.1,109.19 21,109.08 U7101.27
  L5 w0.102: v2(16.06,121.29) 15.85,121.49 15.08,121.49 14.76,121.81 14.76,122.4 11.86,125.3 9.82,125.3 9.43,124.92 8.67,124.92 7.7,123.95 7.7,123.29 7.83,123.17 8.31,123.17 8.44,123.29 8.44,123.55 v2(9.15,124.26)
  BOTTOM w0.114: v2(9.15,124.26) 8.26,124.26 8.07,124.45 JUSB1.A8
USB1_SBU2: length 37
  TOP w0.114: 16.69,119.38 AFTP7102.1 ; 16.69,119.38 16.94,119.64 17.73,119.64 18.14,120.05 18.14,121.34 17.84,121.64 17.2,121.64 17.02,121.82 ED7307.1 16.48,121.92 v2(16.06,121.92) ; 16.69,119.38 16.49,119.19 16.39,119.09 16.39,116.75 16.26,116.61 16.26,115.98 16.01,115.72 16.01,113.79 16.26,113.53 16.26,111.05 17.01,110.3 17.24,110.3 R7330.2 17.66,110.31 20.61,110.31 21.33,109.59 21.33,109.18 21.4,109.11 U7101.26
  L5 w0.076: 6.45,121.95 6.33,122.07 5.98,122.62 JUSB1.B8
  L5 w0.102: 6.45,121.95 6.53,121.87 6.92,121.87 7.29,122.1 7.5,122.3 7.5,124.03 8.59,125.12 9.35,125.12 9.73,125.5 11.95,125.5 14.96,122.49 14.96,121.9 15.17,121.69 15.83,121.69 v2(16.06,121.92)
USB1_SSRX_CMC_N1: length 2.7
  TOP w0.114: C7169.1 17.89,107.9 18.27,107.9 18.97,107.19 U7101.31
USB1_SSRX_CMC_N1_C: length 11.9
  TOP w0.114: C7169.2 16.82,108.1 R7187.1 15.88,108.1 13.86,110.12 13.86,115.1 14.25,115.5 v2(15.03,115.83)
  BOTTOM w0.114: R7120.1 14.28,115.57 14.78,115.57 v2(15.03,115.83)
USB1_SSRX_CMC_N2: length 2.8
  TOP w0.114: C7167.1 17.78,103.11 18.11,103.11 18.57,103.56 18.64,103.59 19.11,103.82 19.44,103.82 19.61,103.99 U7101.39
USB1_SSRX_CMC_N2_C: length 32.1
  TOP w0.114: v2(14.68,127.5) 14.55,127.5 14.42,127.37 14.42,127.06 15.22,126.26 15.22,124.64 14.3,123.72 14.3,120.6 13.71,120.01 13.71,117.61 11.86,115.77 11.86,113.18 10.71,112.03 10.71,111.67 R7185.1 10.7,111.18 10.7,110.41 14.05,107.06 14.05,104.87 15.94,102.97 16.38,102.97 16.51,103.1 16.51,103.33 16.64,103.46 16.87,103.46 C7167.2
  BOTTOM w0.114: v2(14.68,127.5) 14.68,127.66 14.56,127.78 14.42,127.78 14.26,127.94 14.05,127.94 R7123.1
USB1_SSRX_CMC_P1: length 2.8
  TOP w0.114: C7168.1 17.89,108.13 18.36,108.13 19.07,107.42 19.39,107.42 19.57,107.59 U7101.30
USB1_SSRX_CMC_P1_C: length 11.7
  TOP w0.114: C7168.2 17.07,108.29 R7186.1 16.06,108.33 15.97,108.33 14.09,110.22 14.09,115.01 14.34,115.26 14.44,115.26 14.56,115.14 14.56,114.93 14.73,114.86 14.9,114.92 v2(15.01,115.14)
  BOTTOM w0.114: R7119.1 14.35,115.34 14.81,115.34 v2(15.01,115.14)
USB1_SSRX_CMC_P2: length 2.7
  TOP w0.114: U7101.40 19.16,103.59 18.71,103.37 18.2,102.87 C7170.1
USB1_SSRX_CMC_P2_C: length 32.3
  TOP w0.114: v2(14.6,128.22) 14.34,127.82 14.24,127.66 14.19,127.48 14.19,126.96 14.99,126.16 14.99,124.73 14.07,123.82 14.07,120.7 13.48,120.1 13.48,117.71 11.64,115.87 11.64,113.28 10.48,112.12 10.48,111.67 R7188.1 10.47,111.2 10.47,110.32 13.82,106.96 13.82,104.77 15.85,102.74 C7170.2
  BOTTOM w0.114: R7122.1 13.86,128.38 v2(14.6,128.22)
USB1_SSRX_CON_N1: length 13.9
  TOP w0.114: v2(9.59,116.18) 9.39,115.98 9.04,115.98 8.54,116.48 8.54,117.65 9.6,118.72 9.6,119.96 7.82,121.74 6.06,121.74 JUSB1.B10
  BOTTOM w0.114: R7120.2 12.93,115.55 12.73,115.55 12.59,115.68 ED7301.4 ED7301.7 10.3,115.68 10.03,115.95 9.82,115.95 v2(9.59,116.18)
USB1_SSRX_CON_N2: length 7
  BOTTOM w0.114: JUSB1.A10 8.08,125.45 8.21,125.59 8.42,125.59 9.23,126.4 9.23,127.45 9.69,127.91 10.44,127.91 10.54,127.81 ED7302.9 ED7302.2 12.21,127.81 12.35,127.94 12.63,127.94 R7123.2
USB1_SSRX_CON_P1: length 14
  TOP w0.114: v2(9.59,115.55) 9.39,115.75 8.94,115.75 8.31,116.38 8.31,117.75 9.38,118.82 9.38,119.86 7.72,121.51 6.12,121.51 JUSB1.B11
  BOTTOM w0.114: v2(9.59,115.55) 9.77,115.72 9.93,115.72 10.21,115.45 10.64,115.45 10.91,115.18 ED7301.6 ED7301.5 12.59,115.18 12.73,115.32 12.91,115.32 R7119.2
USB1_SSRX_CON_P2: length 7
  BOTTOM w0.114: JUSB1.A11 8.09,125.95 8.23,125.81 8.33,125.81 9.01,126.49 9.01,127.55 9.59,128.13 10.43,128.13 10.6,128.31 ED7302.10 ED7302.1 12.21,128.31 12.35,128.17 12.65,128.17 R7122.2
USB1_SSTX_C_N1: length 2.2
  TOP w0.114: C7163.2 18.18,105.72 18.28,105.82 18.62,105.82 18.85,106.05 19.11,106.05 19.11,106.05 19.5,106.05 19.55,105.99 U7101.34
USB1_SSTX_C_N2: length 2.4
  TOP w0.114: U7101.36 19.57,105.19 19.43,105.06 19.03,105.06 18.53,104.56 18.33,104.56 C7162.2
USB1_SSTX_C_P1: length 2.5
  TOP w0.114: C7164.2 18.04,106.27 18.15,106.15 18.27,106.15 18.37,106.05 18.53,106.05 18.76,106.27 19.01,106.27 19.02,106.28 19.45,106.28 19.57,106.39 U7101.33
USB1_SSTX_C_P2: length 2.3
  TOP w0.114: C7161.2 18.28,104.33 18.63,104.33 19.13,104.83 19.53,104.83 19.57,104.79 U7101.37
USB1_SSTX_CMC_N1: length 15.8
  TOP w0.114: v2(15.04,117.32) 15.04,117.29 13.16,115.41 13.16,109.83 15.32,107.67 15.32,106.46 15.96,105.82 17.02,105.82 C7163.1
  BOTTOM w0.114: v2(15.04,117.32) 14.81,117.1 14.3,117.1 R7117.1
USB1_SSTX_CMC_N2: length 29
  TOP w0.114: v2(16.09,123.67) 15.8,123.95 15.55,123.95 15.01,123.42 15.01,120.28 14.42,119.68 14.42,117.34 12.69,115.61 12.69,109.63 14.76,107.56 14.76,106.1 16.44,104.41 16.66,104.41 16.78,104.54 16.78,104.76 16.87,104.85 C7162.1
  BOTTOM w0.114: v2(16.09,123.67) 15.79,123.97 15.44,123.97 15.07,124.34 15.07,126.46 14.88,126.65 14.25,126.65 13.77,126.16 R7125.1
USB1_SSTX_CMC_P1: length 15
  TOP w0.114: C7164.1 16.67,106.05 16.06,106.05 15.55,106.55 15.55,107.77 13.39,109.93 13.39,115.32 14.72,116.65 v2(15.02,116.65)
  BOTTOM w0.114: R7115.1 14.33,116.87 14.8,116.87 v2(15.02,116.65)
USB1_SSTX_CMC_P2: length 29.2
  TOP w0.114: C7161.1 16.44,104.09 16.09,104.44 14.53,106 14.53,107.47 12.46,109.54 12.46,115.7 14.19,117.43 14.19,119.78 14.79,120.37 14.79,123.51 15.45,124.18 15.79,124.18 v2(16.09,124.48)
  BOTTOM w0.114: R7124.1 14.98,126.87 15.29,126.56 15.29,124.43 15.53,124.19 15.8,124.19 v2(16.09,124.48)
USB1_SSTX_CON_N1: length 9.3
  BOTTOM w0.114: JUSB1.A3 8.87,121.95 9.2,121.62 9.2,120.09 9.63,119.66 9.63,118.1 10.55,117.18 ED7301.10 ED7301.1 13.02,117.18 R7117.2
USB1_SSTX_CON_N2: length 8
  L5 w0.102: v2(9.7,126.18) 9.48,126.39 8.82,126.39 8.11,125.68 6.09,125.68 JUSB1.B3
  BOTTOM w0.114: v2(9.7,126.18) 9.96,126.43 10.5,126.43 10.63,126.31 ED7302.6 ED7302.5 12.21,126.31 12.35,126.44 12.58,126.44 R7125.2
USB1_SSTX_CON_P1: length 9.8
  BOTTOM w0.114: R7115.2 12.82,116.95 12.66,116.95 12.39,116.68 ED7301.2 ED7301.9 10.91,116.68 10.64,116.95 10.46,116.95 9.4,118.01 9.4,119.57 8.97,120 8.97,121.53 8.78,121.72 8.38,121.72 8.33,121.67 8.33,121.52 8.26,121.45 JUSB1.A2
USB1_SSTX_CON_P2: length 7.9
  L5 w0.102: JUSB1.B2 6.12,125.88 8.03,125.88 8.74,126.59 9.48,126.59 v2(9.7,126.81)
  BOTTOM w0.114: v2(9.7,126.81) 9.84,126.67 9.86,126.67 9.86,126.66 10.42,126.66 10.56,126.81 ED7302.7 ED7302.4 12.21,126.81 12.35,126.67 12.7,126.67 R7124.2
USB1_USB20_N: length 113.1
  TOP w0.114: 32.42,116.02 32.13,115.73 32.13,115.28 R7134.1 32.56,114.62 32.63,114.62 v2(33.05,115.04) ; 32.42,116.02 v1(32.52,115.92) ; 32.42,116.02 32.53,116.13 32.53,116.35 32.64,116.46 U7102.2
  L6 w0.102: v2(109.51,110.94) 109.66,111.09 109.77,111.09 109.95,110.91 109.95,109.02 110.91,108.05 112.51,108.05 113.33,108.87 113.33,114.79 110.64,117.48 109.38,117.48 105.72,121.13 102.37,121.13 101.25,122.25 90.21,122.25 89.57,121.62 87.97,121.62 86.32,119.97 65.05,119.97 61.75,116.66 58.28,116.66 57.59,117.35 45.77,117.35 45.29,117.83 42.17,117.83 39.93,115.6 34.55,115.6 33.55,114.59 32.24,114.59 32.03,114.8 32.03,115.04 32.29,115.29 32.8,115.29 v2(33.05,115.04)
  BOTTOM w0.076: CPU1.CD3 107.03,105.59 107.03,106.04 107.18,106.2 107.18,107.95 107.41,108.18 107.45,108.18
  BOTTOM w0.114: v2(109.51,110.94) 109.3,111.15 109.17,111.15 109.06,111.04 109.06,109.79 107.45,108.18
USB1_USB20_N_R: length 10.9
  TOP w0.114: v2(30.67,119.13) R7131.1 ; R7134.2 32.04,113.62 32.04,112.46 v2(32.12,112.38) 32.14,112.36 32.14,112.15 v1(32.4,111.9)
  L5 w0.102: v2(32.12,112.38) 31.91,112.6 31.91,112.9 32.13,113.13 32.13,117.48 31.4,118.21 30.8,118.21 30.67,118.34 v2(30.67,119.13)
USB1_USB20_P: length 113.1
  TOP w0.114: v2(30.86,114.81) R7133.1 31.9,115.35 31.9,115.82 32.31,116.23 32.31,116.39 32.24,116.46 U7102.1
  L6 w0.102: v2(109.51,111.57) 109.8,111.29 109.85,111.29 110.15,110.99 110.15,109.1 110.99,108.26 112.42,108.26 113.12,108.96 113.12,114.71 110.56,117.27 109.3,117.27 105.64,120.93 102.28,120.93 101.16,122.05 90.29,122.05 89.66,121.41 88.06,121.41 86.41,119.76 65.14,119.76 61.83,116.46 58.19,116.46 57.51,117.15 45.69,117.15 45.21,117.63 42.25,117.63 40.02,115.39 34.64,115.39 33.64,114.39 32.15,114.39 31.73,114.81 v2(30.86,114.81)
  BOTTOM w0.076: CPU1.CD4 107.11,105.11 106.85,105.36 106.85,106.12 107,106.27 107,108.02 107.27,108.29 107.27,108.33 107.28,108.34
  BOTTOM w0.114: v2(109.51,111.57) 109.32,111.38 109.07,111.38 ; 109.07,111.38 108.83,111.14 108.83,109.89 107.28,108.34 ; 109.07,111.38 v1(108.94,111.51)
USB1_USB20_P_R: length 10.4
  TOP w0.114: v2(30.69,116.94) 30.41,116.66 R7132.1 ; R7133.2 31.82,113.72 31.82,113.08 ; 31.82,113.08 31.82,112.71 v2(31.49,112.38) ; 31.82,113.08 v1(31.68,113.08)
  L5 w0.102: v2(30.69,116.94) 30.69,117.88 30.81,118.01 31.31,118.01 31.93,117.39 31.93,113.22 31.7,112.99 31.7,112.6 v2(31.49,112.38)
USB2_ID: length 22.4
  TOP w0.089: v1(107.87,102.41) 108,102.41 v2(108.33,102.09)
  L3 w0.089: v2(108.33,102.09) 108.69,102.44 108.69,104.37 109.81,105.49 116.64,105.49 116.99,105.84 121.9,105.84 123,106.94 124.01,106.94 v2(124.74,107.67)
  BOTTOM w0.089: RN1602.1 125.08,108.01 v2(124.74,107.67) ; v2(108.33,102.09) CPU1.CE8
USB2_USB20_N: length 185.6
  TOP w0.114: v2(206.69,40.94) 206.41,41.23 v1(206.2,41.23)
  L5 w0.102: v2(206.69,40.94) 206.91,41.16 209.79,41.16 211.31,42.67 211.31,43.91 211.77,44.38 214.28,44.38 216.31,46.41 216.31,49.02 218.19,50.9 218.19,51.49 219.55,52.85 220.39,52.85 221.85,54.31 221.85,58.94 220.58,60.2 218.34,60.2 216.74,61.8 200.64,61.8 199.16,60.33 191.14,60.33 189.52,58.7 183.11,58.7 179.4,62.41 179.4,62.43 178.31,63.52 178.31,64.13 175.46,66.98 172.5,66.98 171.23,68.25 160.95,68.25 160.78,68.41 132.08,68.41 126.44,74.05 126.44,94.5 124.46,96.48 124.46,97.34 123.45,98.36 123.45,101.23 123.45,101.73 123.25,101.93 123.25,102.23 119.98,105.5 117.84,105.5 117.12,106.23 117.12,107.79 116.32,108.59 110.52,108.59 v2(109.5,109.6)
  BOTTOM w0.076: CPU1.CE1 107.58,106.57 107.58,107.56 107.61,107.58 107.61,107.6
  BOTTOM w0.114: v2(206.69,40.94) 206.49,41.15 206.25,41.15 EL6602.4 ; 107.61,107.6 108.13,108.13 108.92,108.13 109.51,108.72 109.51,109.02 109.5,109.03 109.5,109.2 109.5,109.2 109.5,109.29 109.5,109.29 109.5,109.6 v2(109.5,109.6)
USB2_USB20_N_CMC: length 9.2
  BOTTOM w0.114: EL6602.3 204.5,40.97 204.35,41.12 204.35,41.45 204.14,41.66 202.57,41.66 201.86,42.37 201.54,42.37 ED6601.3 201.05,42.34 200.86,42.34 200.51,41.99 200.51,41.08 199.66,40.23 199.66,39.23 199.8,39.09 IOBD1.8
USB2_USB20_P: length 186.3
  TOP w0.114: v2(206.69,41.58) 206.27,42 206.27,42.52 v1(206.48,42.73)
  L5 w0.102: v2(109.09,109.12) 109.7,109.12 110.43,108.38 116.24,108.38 116.91,107.71 116.91,106.14 117.76,105.3 119.9,105.3 123.05,102.15 123.05,101.84 123.24,101.65 123.24,101.31 123.24,98.27 124.26,97.26 124.26,96.39 126.24,94.41 126.24,73.97 132,68.21 160.7,68.21 160.86,68.05 171.14,68.05 172.41,66.78 175.38,66.78 178.11,64.05 178.11,63.44 179.2,62.35 179.2,62.32 183.03,58.5 189.6,58.5 191.23,60.12 199.25,60.12 200.72,61.6 216.66,61.6 218.26,60 220.5,60 221.64,58.85 221.64,54.39 220.3,53.05 219.46,53.05 217.99,51.57 217.99,50.99 216.11,49.11 216.11,46.49 214.19,44.58 211.69,44.58 211.1,43.99 211.1,42.76 209.71,41.36 206.91,41.36 v2(206.69,41.58)
  BOTTOM w0.076: CPU1.CE2 107.67,106.01 107.4,106.27 107.4,107.72 107.44,107.76
  BOTTOM w0.114: v2(206.69,41.58) 206.54,41.43 206.24,41.43 EL6602.1 ; 107.44,107.76 108.04,108.36 108.83,108.36 109.28,108.81 109.28,108.93 v2(109.09,109.12)
USB2_USB20_P_CMC: length 9.4
  BOTTOM w0.114: IOBD1.9 199.3,39.05 199.44,39.19 199.44,39.93 ; v1(199.27,39.93) 199.44,39.93 ; 199.44,39.93 199.44,40.33 200.28,41.17 200.28,42.08 200.8,42.6 201.8,42.6 201.81,42.6 201.95,42.6 202.66,41.89 203.5,41.89 ED6601.4 203.94,41.89 204.23,41.89 204.47,41.65 EL6602.2
USB2_VBUSSENSE: length 22.1
  L3 w0.089: v2(107.41,103.36) 109.72,105.67 116.56,105.67 116.92,106.02 121.8,106.02 122.94,107.16 123.6,107.16 v2(124.74,108.31)
  BOTTOM w0.089: v2(124.74,108.31) 125.09,108.66 RN1602.2 v1(125.96,109.47) ; CPU1.CC6 v2(107.41,103.36)
USB3_CHAR_2544_N: length 6.6
  TOP w0.114: v1(19.28,49.02) 19.15,49.02 ; 19.15,49.02 19.15,49.33 19.3,49.48 20.73,49.48 21.01,49.76 U3601.11 ; 19.15,49.02 19.15,48.16 19.32,48 19.57,48 v2(19.97,48.39)
  BOTTOM w0.114: R3615.1 20.97,48.11 20.84,47.98 20.37,47.98 v2(19.97,48.39)
USB3_CHAR_2544_P: length 6.5
  TOP w0.114: 19.07,47.92 19.22,47.77 19.95,47.77 v2(19.97,47.75) ; 19.07,47.92 v1(18.95,47.8) ; 19.07,47.92 18.92,48.07 18.92,49.42 19.21,49.71 20.39,49.71 20.51,49.84 U3601.10
  BOTTOM w0.114: v2(19.97,47.75) 20.93,47.75 21.25,48.07 R3614.1
USB3_CHAR_N: length 4.7
  BOTTOM w0.114: 20.25,50.58 v1(20.14,50.47) ; 20.25,50.58 20.33,50.5 21.19,50.5 22.1,49.58 22.1,49.4 21.94,49.24 R3615.2 ; 20.25,50.58 19.97,50.85 19.42,50.85 19.29,50.73 EL3501.4
USB3_CHAR_P: length 5.9
  BOTTOM w0.114: R3616.2 22.13,48.71 22.13,49.1 22.33,49.31 22.33,49.68 22.16,49.85 ; EL3501.1 18.61,50.46 19.23,51.08 20.07,51.08 20.42,50.73 21.28,50.73 22.16,49.85 ; 22.16,49.85 v1(22.28,49.96)
USB3_NONPS_N: length 15
  TOP w0.114: v1(20.5,48.77) 20.22,48.77 v2(19.97,49.02) ; v2(21.67,54.18) 21.67,54.1 21.8,53.98 R3611.2
  L5 w0.102: v2(19.97,49.02) 20.3,49.02 20.4,48.92 20.4,48.27 20.53,48.15 20.71,48.15 20.86,48.29 20.86,51.01 21.27,51.42 21.27,52.72 22.23,53.69 22.23,55.68 22.11,55.81 21.78,55.81 21.67,55.69 v2(21.67,54.18)
  BOTTOM w0.114: v2(19.97,49.02) 20.6,49.66 R3617.1
USB3_NONPS_P: length 14.5
  TOP w0.114: R3610.2 v2(22.05,56.44)
  L5 w0.102: v2(22.05,56.44) 22.44,56.05 22.44,53.6 21.47,52.64 21.47,51.34 21.06,50.93 21.06,48.21 v2(19.97,47.12)
  BOTTOM w0.114: R3616.1 21.83,47.19 20.48,47.19 ; v2(19.97,47.12) 20.02,47.12 20.09,47.19 20.48,47.19 ; 20.48,47.19 v1(20.48,47.37)
USB3_USB20_2544_N: length 3.7
  TOP w0.114: 20.74,54.28 20.74,53.86 21.01,53.59 U3601.2 ; 20.74,54.28 v1(20.88,54.28) ; 20.74,54.28 20.74,55.14 20.97,55.37 21.34,55.37 R3613.1
USB3_USB20_2544_P: length 3.7
  TOP w0.114: v1(21.03,55.75) 21.03,55.6 ; 21.03,55.6 R3612.1 ; 21.03,55.6 20.88,55.6 20.51,55.24 U3601.3
USB3_USB20_CON_N: length 18.4
  TOP w0.114: USB1.2 13.14,55.88 13.25,55.76 15.1,55.76 15.47,55.39 15.47,51.11 17.61,48.97 17.61,48.57 17.39,48.35 ; 17.39,48.35 AFTP3502.1 ; 17.39,48.35 17.02,47.99 v2(15.75,47.99)
  BOTTOM w0.114: v2(15.75,47.99) 15.75,47.99 16.22,47.52 17.95,47.52 18.42,47.99 ED3502.1 19.29,48.16 EL3501.3
USB3_USB20_CON_P: length 17
  TOP w0.114: 16.44,49.81 16.7,49.55 17.38,48.88 17.38,48.67 16.93,48.22 16.18,48.22 v2(15.78,48.63) ; 16.44,49.81 AFTP3503.1 ; 16.44,49.81 15.24,51.01 15.24,55.3 15,55.54 13.25,55.54 13.14,55.42 USB1.3
  BOTTOM w0.114: v2(15.78,48.63) 15.95,48.63 16.58,47.99 ED3502.6 16.82,47.99 17.06,47.75 17.86,47.75 18.77,48.67 18.77,49.06 EL3501.2
USB3_USB20_N: length 157
  TOP w0.114: v2(23.53,55.35) 23.29,55.35 R3613.2
  L6 w0.102: v2(23.53,55.35) 23.8,55.35 23.96,55.5 23.96,55.6 24.06,55.7 24.47,55.7 24.84,56.08 24.84,57.6 25.36,58.12 27.91,58.12 30.48,60.69 30.48,65.44 32.31,67.27 33.15,67.27 34.13,68.26 38.39,68.26 39.53,69.4 40.46,69.4 45.77,74.72 45.77,77.93 46.76,78.93 46.76,80.95 48.85,83.03 49.77,83.03 50.52,83.79 50.52,87.68 49.38,88.83 49.38,92.3 47.51,94.18 47.51,99.91 48.09,100.49 48.09,103.42 50.47,105.8 50.47,111.19 52.33,113.06 54.94,113.06 55.65,113.77 61.67,113.77 66.5,118.59 86.89,118.59 88.44,120.14 90.2,120.14 90.87,120.81 100.72,120.81 102.7,118.83 105.98,118.83 108.81,116 110.1,116 111.95,114.15 111.95,112.53 111.84,112.41 111.7,112.41 v2(111.48,112.61)
  BOTTOM w0.076: CPU1.CE3 107.7,105.21 107.92,105.73 107.92,105.94 107.89,106.02 107.89,106.3 107.92,106.38 107.92,106.68 107.84,106.76 107.82,107.41 108.13,107.71 108.13,107.75
  BOTTOM w0.114: v2(111.48,112.61) 111.33,112.76 111.1,112.76 110.98,112.63 110.98,112.37 ; 110.98,112.37 v1(110.77,112.37) ; 110.98,112.37 110.98,111.75 110.18,110.95 110.18,110.16 110.03,110.01 110.03,108.95 108.98,107.9 108.28,107.9 108.13,107.75
USB3_USB20_P: length 157
  TOP w0.114: R3612.2 23.14,55.6 v2(23.52,55.98)
  L6 w0.102: v2(111.52,111.96) 111.76,112.21 111.92,112.21 112.16,112.44 112.16,114.23 110.18,116.21 108.89,116.21 106.06,119.04 102.79,119.04 100.81,121.01 90.78,121.01 90.12,120.35 88.36,120.35 86.81,118.8 66.41,118.8 61.59,113.97 55.57,113.97 54.86,113.26 52.24,113.26 50.26,111.28 50.26,105.89 47.88,103.51 47.88,100.58 47.3,100 47.3,94.09 49.18,92.22 49.18,88.74 50.32,87.6 50.32,83.87 49.69,83.24 48.76,83.24 46.56,81.04 46.56,79.01 45.57,78.02 45.57,74.8 40.37,69.61 39.45,69.61 38.3,68.46 34.05,68.46 33.06,67.48 32.23,67.48 30.28,65.53 30.28,60.78 27.82,58.32 25.28,58.32 24.64,57.68 24.64,56.16 24.39,55.91 23.6,55.91 v2(23.52,55.98)
  BOTTOM w0.076: 108.29,107.58 108.27,107.57 108.24,107.57 108,107.34 108.02,106.83 108.1,106.75 108.1,106.34 108.09,106.31 108.07,106.27 108.07,106.05 108.09,106.01 108.1,105.98 108.1,105.69 107.95,105.34 107.95,104.81 CPU1.CE4
  BOTTOM w0.114: v1(110.68,110.94) 110.59,111.03 ; 110.59,111.03 110.41,110.85 110.41,110.07 110.26,109.92 110.26,108.85 109.08,107.67 108.38,107.67 108.29,107.58 ; 110.59,111.03 v2(111.52,111.96)
USB3_USB30_RX_CON_N: length 8.6
  BOTTOM w0.114: EL3503.3 18.52,52.42 18.11,52.42 17.98,52.29 ED3501.10 ED3501.1 14.68,52.29 13.8,53.16 12.58,53.16 11.64,52.23 USB1.5
USB3_USB30_RX_CON_P: length 8.1
  BOTTOM w0.114: EL3503.4 18.57,52.64 18.11,52.64 17.98,52.77 ED3501.9 ED3501.2 16.37,52.77 16.12,52.52 14.77,52.52 13.9,53.39 12.75,53.39 12.16,53.99 11.98,53.99 USB1.6
USB3_USB30_TX_CMC_N: length 3.1
  BOTTOM w0.114: EL3502.1 20,53.73 20.42,54.15 20.69,54.15 21.42,53.42 21.95,53.42 22.02,53.49 22.31,53.49 C3521.2
USB3_USB30_TX_CMC_P: length 3.1
  BOTTOM w0.114: C3520.2 21.85,53.65 21.52,53.65 20.78,54.38 EL3502.2
USB3_USB30_TX_CON_N: length 10.5
  BOTTOM w0.114: R3507.1 18.55,53.94 18.37,53.94 18.37,53.94 18.11,53.94 17.98,53.81 ED3501.7 ED3501.4 16.25,53.81 16,54.06 15.52,54.06 14.91,54.67 14.91,56.83 13.75,57.99 11.98,57.99 USB1.8
USB3_USB30_TX_CON_P: length 11.2
  BOTTOM w0.114: USB1.9 12.25,59.04 12.25,58.46 12.49,58.22 13.85,58.22 15.14,56.92 15.14,54.76 15.61,54.29 ED3501.5 ED3501.6 17.98,54.29 18.11,54.16 18.27,54.16 18.27,54.17 18.55,54.17 R3501.1
USB3_USB31_RX_N: length 153
  L6 w0.102: v2(106.53,103.46) 106.46,103.46 106.23,103.69 106.23,104.6 106.76,105.13 106.76,109.41 107.42,110.07 107.42,114.69 104.89,117.23 101.81,117.23 100.87,118.16 96.1,118.16 95.97,118.3 91.53,118.3 90.5,117.27 89.15,117.27 88.33,116.46 67.5,116.46 62.54,111.51 56.99,111.51 54.84,109.36 54.84,103.68 50.55,99.39 50.55,94.25 51.77,93.03 51.77,90.56 53.06,89.27 53.06,80.59 51.72,79.25 50.97,79.25 49.74,78.01 49.74,75.99 44.35,70.61 44.35,69.32 42.65,67.62 42.12,67.62 38.23,63.73 35.81,63.73 34.6,62.52 34.6,59.11 32.98,57.48 32.98,56.32 32.48,55.83 31.32,55.83 29.31,53.82 26.4,53.82 25.89,53.32 25.25,53.32 25.12,53.44 25.12,53.8 25.25,53.92 v2(25.36,53.92)
  BOTTOM w0.114: CPU1.CB5 106.35,103.46 v2(106.53,103.46) ; v2(25.36,53.92) 25.28,53.92 25.15,53.8 25.15,53.28 24.26,52.39 20.02,52.39 EL3503.1
USB3_USB31_RX_P: length 153.6
  L6 w0.102: v2(24.74,54.15) 24.92,53.98 24.92,53.36 25.17,53.11 25.98,53.11 26.49,53.62 29.4,53.62 31.41,55.63 32.57,55.63 33.18,56.24 33.18,57.4 34.8,59.02 34.8,62.43 35.89,63.53 38.31,63.53 42.2,67.41 42.73,67.41 44.55,69.23 44.55,70.52 49.94,75.91 49.94,77.93 51.06,79.05 51.8,79.05 53.27,80.51 53.27,89.35 51.97,90.65 51.97,93.12 50.75,94.34 50.75,99.31 55.04,103.6 55.04,109.27 57.08,111.3 62.63,111.3 67.58,116.26 88.42,116.26 89.23,117.07 90.59,117.07 91.61,118.1 95.88,118.1 96.02,117.96 100.79,117.96 101.72,117.02 104.8,117.02 107.22,114.61 107.22,110.15 106.56,109.49 106.56,105.21 106.02,104.68 106.02,103.33 v2(106.53,102.82)
  BOTTOM w0.114: CPU1.CB6 106.34,102.82 v2(106.53,102.82) ; EL3503.2 20.02,52.62 24.16,52.62 24.92,53.37 24.92,53.98 v2(24.74,54.15)
USB3_USB31_TX_N: length 149.8
  L6 w0.102: v2(25.92,54.63) 25.85,54.57 25.85,54.33 25.98,54.2 26.24,54.2 26.5,54.46 26.68,54.46 26.94,54.21 29.09,54.21 34.14,59.25 34.14,63.02 35.33,64.21 38.08,64.21 41.86,67.99 41.86,68.73 49.33,76.19 49.33,79.4 49.66,79.73 50.75,79.73 52.58,81.56 52.58,88.49 51.39,89.69 51.39,92.77 50.08,94.08 50.08,99.61 52.45,101.98 52.45,103.3 54.38,105.23 54.38,109.48 56.85,111.94 62.39,111.94 67.29,116.84 88.18,116.84 89.41,118.07 90.73,118.07 91.41,118.76 96.05,118.76 96.26,118.54 101.08,118.54 102.02,117.61 105.44,117.61 108.33,114.72 108.33,113.71 108.2,113.57 108.06,113.57 v2(107.89,113.73)
  BOTTOM w0.076: CPU1.CA4 105.23,104.71 104.96,104.98 104.96,105.36 105.13,105.53 105.35,105.53 105.43,105.6 105.46,105.67 105.48,105.73 105.48,105.94 105.45,106.02 105.45,106.3 105.48,106.38 105.48,106.7 105.29,106.89 105.29,107.42 105.75,107.88 105.75,108.61 105.72,108.63 105.72,108.65
  BOTTOM w0.114: v2(25.92,54.63) 25.92,54.82 25.68,55.06 25.07,55.06 24.94,54.93 23.88,53.96 23.81,53.89 23.79,53.87 23.78,53.86 C3521.1 ; 105.72,108.65 105.72,108.89 106.63,109.8 106.63,113.2 107.16,113.73 v2(107.89,113.73)
USB3_USB31_TX_P: length 149.1
  L6 w0.102: v2(107.89,112.98) 108.25,113.34 108.25,113.34 108.54,113.62 108.54,114.8 105.53,117.81 102.1,117.81 101.17,118.75 96.34,118.75 96.13,118.96 91.32,118.96 90.64,118.28 89.32,118.28 88.09,117.04 67.21,117.04 62.3,112.14 56.76,112.14 54.18,109.56 54.18,105.32 52.25,103.39 52.25,102.07 49.88,99.69 49.88,94 51.18,92.69 51.18,89.6 52.38,88.41 52.38,81.64 50.67,79.94 49.58,79.94 49.13,79.49 49.13,76.28 41.66,68.81 41.66,68.07 38,64.41 35.24,64.41 33.94,63.1 33.94,59.34 29.01,54.41 27.02,54.41 v2(26.27,55.17)
  BOTTOM w0.076: CPU1.CA3 105.28,105.13 105.51,105.13 105.59,105.21 105.59,105.53 105.64,105.66 105.66,105.67 105.66,105.97 105.63,106.05 105.63,106.27 105.65,106.32 105.66,106.35 105.66,106.77 105.47,106.97 105.47,107.35 105.92,107.81 105.92,108.61 105.95,108.63 105.95,108.65
  BOTTOM w0.114: v2(26.27,55.17) 25.9,55.17 25.77,55.29 24.97,55.29 24.78,55.1 23.73,54.13 23.65,54.06 23.63,54.04 23.62,54.03 23.44,54.03 C3520.1 ; 105.95,108.65 105.95,108.79 106.86,109.7 106.86,113.1 107.26,113.51 107.53,113.51 107.89,113.14 v2(107.89,112.98)
USB4_USB20_CON_N: length 26.8
  L3 w0.089: v2(15.21,45.32) 15.44,45.09 15.44,44.87 13.83,43.27 12.85,43.27 11.98,42.4 11.98,39.83 14.09,37.71 14.09,31.22 13.71,30.84 13.34,30.84 13.14,31.03 USB2.2
  BOTTOM w0.114: EL3506.2 21.12,46.67 20.27,45.82 19.4,45.82 ED3502.3 18.86,45.82 18.27,45.82 17.53,46.56 16.16,46.56 15.45,45.85 15.45,45.55 v2(15.21,45.32)
USB4_USB20_CON_P: length 26.4
  TOP w0.114: v1(16.33,45.03) 16.14,45.03 v2(15.85,45.31)
  L3 w0.089: USB2.3 14.28,31.14 14.28,37.79 12.17,39.9 12.17,42.32 12.93,43.08 13.91,43.08 15.63,44.79 15.63,44.96 15.63,45.09 v2(15.85,45.31)
  BOTTOM w0.114: v2(15.85,45.31) 15.85,45.34 15.67,45.52 15.67,45.75 16.25,46.33 16.45,46.33 ED3502.4 16.92,46.32 17.44,46.32 18.17,45.59 20.37,45.59 20.76,45.99 EL3506.3
USB4_USB20_N: length 163.7
  TOP w0.114: v1(23.86,47.03) 23.61,47.03 v2(23.36,46.78)
  L6 w0.102: v2(23.36,46.78) 23.26,46.68 23.11,46.68 22.98,46.81 22.98,49.78 24.79,51.59 24.79,52.58 24.23,53.14 24.23,54.43 24.52,54.73 24.84,54.73 25.7,55.59 25.97,55.59 26.12,55.74 27.24,55.74 28.14,54.84 28.82,54.84 33.48,59.51 33.48,64.2 34.58,65.3 37.96,65.3 41.2,68.55 41.2,68.91 46.46,74.17 46.46,77.75 47.5,78.79 47.5,79.3 49.1,80.9 50.13,80.9 51.13,81.9 51.13,87.97 50.19,88.9 50.19,92.32 48.83,93.68 48.83,103.17 51.6,105.94 51.6,111.31 52.77,112.47 55.19,112.47 55.88,113.16 61.89,113.16 66.74,118.01 87.13,118.01 88.51,119.38 90.26,119.38 91.03,120.14 94.32,120.14 94.4,120.23 100.44,120.23 102.45,118.22 105.72,118.22 108.6,115.34 109.93,115.34 110.76,114.51 110.76,111.79 111.13,111.43 111.13,110.24 111.38,109.98 v2(111.74,109.98)
  BOTTOM w0.076: 109.1,107.08 109.04,107.02 109.04,106.95 108.73,106.64 108.73,106.38 108.76,106.3 108.76,106.02 108.73,105.94 108.73,105.73 108.96,105.21 CPU1.CG3
  BOTTOM w0.114: EL3506.1 22.8,46.67 22.98,46.5 23.07,46.5 v2(23.36,46.78) ; 109.1,107.08 111.11,109.09 111.11,109.95 111.34,110.19 111.54,110.19 v2(111.74,109.98)
USB4_USB20_P: length 164.5
  L6 w0.102: v2(23.36,46.15) 23.29,46.21 22.78,46.73 22.78,49.86 24.59,51.67 24.59,52.49 24.03,53.06 24.03,54.52 24.44,54.93 24.76,54.93 25.62,55.79 25.89,55.79 26.04,55.95 27.32,55.95 28.23,55.04 28.73,55.04 33.28,59.59 33.28,64.29 34.5,65.51 37.87,65.51 41,68.63 41,69 46.26,74.25 46.26,77.83 47.3,78.87 47.3,79.38 49.02,81.1 50.04,81.1 50.92,81.98 50.92,87.88 49.99,88.82 49.99,92.23 48.62,93.6 48.62,103.25 51.4,106.03 51.4,111.39 52.68,112.68 55.11,112.68 55.79,113.36 61.81,113.36 66.66,118.21 87.05,118.21 88.42,119.58 90.18,119.58 90.94,120.35 94.24,120.35 94.32,120.43 100.53,120.43 102.54,118.42 105.81,118.42 108.68,115.55 110.01,115.55 110.97,114.59 110.97,111.87 111.33,111.51 111.33,111.03 v2(111.72,110.64)
  BOTTOM w0.076: 108.94,107.25 108.86,107.16 108.86,107.02 108.55,106.72 108.55,106.34 108.56,106.31 108.58,106.27 108.58,106.05 108.56,106.01 108.55,105.98 108.55,105.69 108.7,105.34 108.7,104.81 CPU1.CG4
  BOTTOM w0.114: v1(110.72,109.42) 110.88,109.42 ; 110.88,109.42 110.88,109.18 108.94,107.25 ; 110.88,109.42 110.88,110.05 111.24,110.42 111.49,110.42 v2(111.72,110.64) ; v2(23.36,46.15) 23.24,46.27 23,46.27 22.72,45.99 EL3506.4
USB4_USB30_RX_C_N: length 7.7
  TOP w0.114: v1(27.36,97.72) C7106.2 27.02,98.68 25.16,98.68 24.41,99.44 22.04,99.44 21.72,99.77 21.72,100.08 R7155.1
USB4_USB30_RX_C_P: length 6.9
  TOP w0.114: R7156.1 21.95,100.05 21.95,99.86 22.14,99.67 24.5,99.67 25.26,98.91 25.58,98.91 ; C7105.2 26.98,99.37 26.85,99.24 26.85,99.02 26.74,98.91 25.58,98.91 ; v1(25.58,99.06) 25.58,98.91
USB4_USB30_RX_C_R_N: length 1.9
  TOP w0.114: R7155.2 21.69,101.42 21.69,102.02 21.89,102.21 21.89,102.43 21.8,102.51 U7101.4
USB4_USB30_RX_C_R_P: length 1.9
  TOP w0.114: U7101.5 22.2,102.51 22.11,102.43 22.11,102.12 21.92,101.92 21.92,101.5 R7156.2
USB4_USB30_RX_CON_N: length 21.5
  BOTTOM w0.114: USB2.5 12.26,27.85 12.88,28.47 13.25,28.47 14.99,30.21 14.99,38.28 15.27,38.56 15.27,42.77 15.44,42.94 16.22,42.94 16.34,42.82 ED3503.1 ED3503.10 17.99,42.82 18.11,42.94 18.51,42.94 18.79,42.65 EL3505.3
USB4_USB30_RX_CON_P: length 21.5
  BOTTOM w0.114: USB2.6 12.08,29.44 12.37,29.44 12.5,29.31 12.5,28.83 12.63,28.7 13.16,28.7 14.76,30.3 14.76,38.37 15.04,38.65 15.04,42.86 15.35,43.17 16.22,43.17 16.35,43.3 ED3503.2 ED3503.9 18.02,43.3 18.14,43.17 18.51,43.17 18.64,43.3 EL3505.4
USB4_USB30_RX_N: length 98.8
  TOP w0.114: 39.98,97.78 50.06,97.78 51.31,96.53 52.19,96.53 v2(52.38,96.34) ; 39.98,97.78 39.59,97.78 37.85,99.52 29.65,99.52 29.01,98.88 28.55,98.88 C7106.1 ; 39.98,97.78 v1(39.98,97.64)
  L6 w0.102: v2(52.38,96.34) 52.62,96.57 53.33,96.57 54.44,97.68 54.44,99.67 58.45,103.68 59.85,103.68 63.46,107.29 64.63,107.29 66.2,108.86 66.2,109.63 67.61,111.05 67.61,111.99 68.84,113.22 72.95,113.22 73.65,113.92 90.76,113.92 92.46,115.62 99.76,115.62 103.66,111.72 103.66,108.5 104.19,107.96 104.19,106.5 103.71,106.02 103.71,104.2 104.23,103.68 104.47,103.68 v2(104.67,103.48)
  BOTTOM w0.114: v2(104.67,103.48) 104.67,103.48 104.47,103.28 CPU1.BW6
USB4_USB30_RX_P: length 98.9
  TOP w0.114: C7105.1 28.53,99.11 28.92,99.11 29.34,99.54 ; v1(29.24,99.65) 29.34,99.54 ; 29.34,99.54 29.56,99.75 37.94,99.75 39.69,98.01 50.16,98.01 51.4,96.76 52.18,96.76 v2(52.38,96.97)
  L6 w0.102: v2(104.7,104.14) 104.45,103.89 104.31,103.89 103.92,104.28 103.92,105.94 104.4,106.42 104.4,108.05 103.86,108.58 103.86,111.8 99.84,115.82 92.37,115.82 90.67,114.12 73.56,114.12 72.86,113.43 68.76,113.43 67.41,112.08 67.41,111.13 65.99,109.71 65.99,108.94 64.54,107.49 63.38,107.49 59.77,103.89 58.36,103.89 54.23,99.76 54.23,97.77 53.24,96.78 52.58,96.78 v2(52.38,96.97)
  BOTTOM w0.114: v2(104.7,104.14) 104.68,104.06 104.18,103.79 CPU1.BW5
USB4_USB30_TX_C_N: length 2.4
  TOP w0.114: 26.01,100.65 26.71,100.65 C7104.2 ; 26.01,100.65 25.21,100.65 R7153.1 ; 26.01,100.65 v1(26.01,100.48)
USB4_USB30_TX_C_P: length 3.1
  TOP w0.114: v1(24.95,102.03) R7154.1 25.21,100.88 26.71,100.88 C7103.2
USB4_USB30_TX_C_R_N: length 3.3
  TOP w0.114: 23.33,100.8 23.09,101.05 23.09,102.27 23,102.36 U7101.7 ; 23.33,100.8 23.52,100.61 23.85,100.61 R7153.2 ; 23.33,100.8 v1(23.22,100.69)
USB4_USB30_TX_C_R_P: length 2.9
  TOP w0.114: 23.31,101.9 23.31,101.14 23.62,100.84 23.78,100.84 R7154.2 ; 23.31,101.9 23.31,102.27 23.4,102.36 U7101.8 ; 23.31,101.9 v1(23.45,101.9)
USB4_USB30_TX_CMC_N: length 1.7
  BOTTOM w0.114: EL3504.1 20.56,44.25 20.75,44.45 21.32,44.45 C3523.2
USB4_USB30_TX_CMC_P: length 1.7
  BOTTOM w0.114: C3522.2 21.39,44.71 20.73,44.71 20.53,44.9 EL3504.2
USB4_USB30_TX_CON_N: length 18.4
  BOTTOM w0.114: USB2.8 11.94,33.3 13.69,33.3 14.28,33.89 14.28,37.67 13.34,38.61 13.34,40.04 14.56,41.26 14.56,43.09 15.9,44.43 16.4,44.43 16.49,44.34 ED3503.4 ED3503.7 18.01,44.34 18.14,44.46 18.88,44.46 EL3504.3
USB4_USB30_TX_CON_P: length 19.1
  BOTTOM w0.114: EL3504.4 18.88,44.69 18.11,44.69 17.99,44.82 ED3503.6 ED3503.5 16.52,44.82 16.36,44.65 15.8,44.65 14.33,43.18 14.33,41.35 13.11,40.13 13.11,38.51 14.05,37.57 14.05,33.99 13.59,33.53 12.68,33.53 11.64,34.57 USB2.9
USB4_USB30_TX_N: length 97.1
  TOP w0.114: 51.57,97.69 51.23,97.69 50.45,98.48 39.88,98.48 38.13,100.23 29.14,100.23 28.79,100.59 28.1,100.59 C7104.1 ; 51.57,97.69 v2(52.44,97.69) ; 51.57,97.69 v1(51.57,97.54)
  L6 w0.102: v2(52.44,97.69) 52.63,97.89 53.32,97.89 53.83,98.4 53.83,99.89 58.28,104.34 59.6,104.34 63.14,107.89 64.39,107.89 65.61,109.11 65.61,109.88 67.01,111.28 67.01,112.21 68.6,113.81 72.66,113.81 73.36,114.5 90.5,114.5 92.2,116.2 100.05,116.2 103.86,112.4 v2(105.03,112.4)
  BOTTOM w0.076: 104.5,108.29 104.5,108.27 104.47,108.24 104.47,107.91 104.4,107.84 104.4,106.46 104.18,106.06 CPU1.BW2
  BOTTOM w0.114: 104.5,108.29 104.5,112.46 104.61,112.57 104.86,112.57 v2(105.03,112.4)
USB4_USB30_TX_P: length 97.3
  TOP w0.114: 28.71,100.81 28.88,100.81 29.24,100.46 38.23,100.46 39.98,98.71 50.54,98.71 51.33,97.92 52.03,97.92 v2(52.44,98.32) ; 28.71,100.81 v1(28.71,100.97) ; 28.71,100.81 28.22,100.81 C7103.1
  L6 w0.102: v2(52.44,98.32) 52.67,98.09 53.23,98.09 53.62,98.48 53.62,99.97 58.2,104.55 59.52,104.55 63.06,108.09 64.3,108.09 65.41,109.2 65.41,109.97 66.81,111.36 66.81,112.3 68.52,114.01 72.58,114.01 73.27,114.71 90.42,114.71 92.12,116.41 100.13,116.41 103.94,112.6 104.44,112.6 104.56,112.73 104.56,112.9 104.69,113.03 v2(105.03,113.03)
  BOTTOM w0.076: 104.27,108.29 104.27,108.24 104.29,108.22 104.29,107.98 104.22,107.91 104.22,106.61 CPU1.BW1
  BOTTOM w0.114: v2(105.03,113.03) 104.8,112.8 104.52,112.8 104.27,112.55 104.27,108.29
USB4_USB31_RX_N: length 156.4
  L6 w0.102: v2(23.39,42.14) 23.54,42.29 23.93,42.29 24.9,43.26 24.9,49.42 27.55,52.07 30.18,52.07 31.22,53.11 33.3,53.11 35.31,55.12 35.31,56.84 39.32,60.85 39.32,62.68 41.37,64.73 42.78,64.73 43.84,65.8 43.84,66.69 45.88,68.73 45.88,70.05 47.51,71.68 50.75,71.68 51.11,72.04 51.11,77.44 51.45,77.78 52.4,77.78 55.29,80.67 55.29,89.02 53.17,91.14 53.17,93.57 51.92,94.82 51.92,98.81 58.62,105.51 59.87,105.51 62.61,108.26 62.61,109.46 67.55,114.39 72.39,114.39 73.09,115.09 90.26,115.09 91.96,116.79 100.29,116.79 101.31,115.77 104.03,115.77 105.44,114.37 105.44,113.2 105.44,113.2 105.44,112.23 105.43,112.21 105.43,107.65 105.21,107.43 105.21,103.99 105.08,103.86 105.08,103.2 105.49,102.8 v2(105.51,102.8)
  BOTTOM w0.114: v2(105.51,102.8) 105.4,102.8 CPU1.BY7 ; EL3505.1 20.35,42.89 22.02,42.89 22.57,42.34 23.19,42.34 v2(23.39,42.14)
USB4_USB31_RX_P: length 156.3
  L6 w0.102: v2(23.39,42.77) 23.67,42.5 23.85,42.5 24.69,43.34 24.69,49.5 27.46,52.27 30.1,52.27 31.14,53.32 33.22,53.32 35.11,55.2 35.11,56.92 39.12,60.94 39.12,62.76 41.29,64.94 42.7,64.94 43.64,65.88 43.64,66.78 45.67,68.81 45.67,70.13 47.42,71.88 50.67,71.88 50.9,72.12 50.9,77.52 51.36,77.98 52.32,77.98 55.09,80.75 55.09,88.93 52.96,91.06 52.96,93.49 51.72,94.74 51.72,98.89 58.54,105.72 59.79,105.72 62.41,108.34 62.41,109.54 67.46,114.59 72.3,114.59 73,115.29 90.18,115.29 91.88,116.99 100.38,116.99 101.39,115.98 104.11,115.98 105.64,114.45 105.64,113.29 105.64,113.28 105.64,112.14 105.63,112.13 105.63,107.57 105.41,107.35 105.41,103.9 105.33,103.82 105.33,103.64 v2(105.51,103.46)
  BOTTOM w0.114: EL3505.2 20.3,43.12 22.11,43.12 22.66,42.57 22.86,42.57 22.94,42.65 22.94,42.85 23.07,42.98 23.26,42.98 23.39,42.85 v2(23.39,42.77) ; CPU1.BY6 105.25,103.14 105.51,103.4 v2(105.51,103.46)
