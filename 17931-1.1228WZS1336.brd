# Allegro board 17931-1.1228WZS1336.brd (continued)
## Nets (continued)
PCIE_RCOMPP: CPU1.CE5 R1604.2
PCIE_WAKE#: D2404.3 R2495.2 U2401.4
PD4403_A: PD4404.A PQ4408.B
PD4403_K: PD4404.K PR4452.2 PR4477.2
PD_SWD_CLK: TP7201.1 U7201.1
PD_VBUS_C_CTRL1: Q7405.2 Q7406.5 U7201.15
PD_VBUS_C_CTRL1_A: Q7404.3 Q7405.1
PD_VBUS_C_CTRL1_R: Q7405.5 Q7405.6 R7426.2 R7429.1
PD_VBUS_C_EN_A: Q7405.3 Q7407.5 Q7407.6 R7425.2 R7431.1
PD_VBUS_C_EN_B: Q7407.3 R7422.1 R7427.2 R7433.2 U7419.A3
PD_VBUS_DISCHG: Q7408.G R7415.1 U7201.12
PD_VBUS_DISCHG_N1: Q7408.D R7410.2
PD_VCCD: C7202.1 U7201.22
PD_XRES: C7213.1 R7211.1 U7201.7
PDB_R: HDA27.40 R2712.2
PECI_CPU: CPU1.AR1 R2437.2
PEQ: R5805.2 R5816.2 U5802.8
PEX_PLLVDD: C7632.1 C7633.1 C7634.1 GPU1.AA14 GPU1.AA15 L7602.1
PEX_SVDD: C7615.1 C7624.1 GPU1.AB8 R7616.1
PEX_TERMP: GPU1.AF25 R7601.1
PEX_TSTCLK_OUT: GPU1.AF22 R7604.1
PEX_TSTCLK_OUT#: GPU1.AE22 R7604.2
PIRQA#: CPU1.CC32 R2053.2 R9152.2
PLTRST#_CPU: AFTP6108.1 C1701.1 ED1701.2 R1713.1 R1715.1 R2616.1 SSD1.50 U3101.19 U7601.2 U9103.17 WLAN1.52 WWAN1.19
PM_LAN_ENABLE: R2466.1 U4001.5
PM_RSMRST#: CPU1.BP30 CPU1.BR36 Q1701.3 Q1702.2 R1702.1 RN1703.4(B)
PM_RSMRST#_M: Q1702.5 Q1702.6 R1737.2
POWER_SW_IN#: C2426.1 R2432.2 R2451.1 U2401.127
PQ3802_1: Q4302.B R4302.1 R4309.2
PQ4348_D: Q4448.D R4466.2 R4469.1
PQ4405_2: PQ4405.2 PR4462.1 PR4463.1
PQ4405_3: PQ4405.3 PR4476.1
PQ4405_5: PC4438.1 PQ4405.5 PR4474.2
PQ4405_6: PC4438.2 PQ4405.6 PR4450.1
PQ4408_C: PQ4408.C PR4462.2 PR4475.1
PQ4408_E: PQ4408.E PR4436.1 PR4473.2
PQ4417_D: PQ4417.D PR4431.2 PR4498.2
PQ4417_G: PQ4417.G PR4430.1
PQ4418_2: PQ4418.2 PR4498.1 PR4499.1
PQ4418_3: PQ4418.3 PR4433.1
PQ4418_5: PC4449.1 PQ4418.5 PR4497.2
PQ4418_6: PC4449.2 PQ4418.6 PR4432.1
PRIM_PWRGD: R4030.1 U2401.30
PROCHOT: Q2408.G R2417.1 U2401.83
PROCHOT#_CPU: ED2403.2 PQ4416.3 PR4433.2 PR4476.2 PR4603.2 PR4607.1 Q2408.D R301.2 R302.1
PROCHOT#_CPU_R: CPU1.Y4 R302.2
PROJECT_ID0: CPU1.CH23 R2113.2 R2114.1
PROJECT_ID1: CPU1.CK19 R2111.2 R2112.1
PROJECT_ID2: CPU1.CG17 R2117.2 R2118.1
PROJECT_ID3: CPU1.CN20 R2115.2 R2116.1
PS_ID: D4302.3 R4304.2 R4305.2 U2401.36
PS_ID_R: AFTP4304.1 DCIN1.4 EC4311.1 ED4303.2 Q4301.D R4309.1
PS_ID_R1: Q4301.S R4305.1
PSID_DISABLE#_R_C: Q4301.G Q4302.C R4303.2
PTP_DIS#: AFTP6526.1 TP1.3 U2401.90
PU4348_G: Q4448.G R4467.1 R4468.2 R4469.2
PULSAR_38P4M_REFCLK: R1804.2 WLAN1.64
PURE_HW_SHUTDOWN#: C2610.1 D4001.K Q2602.D R2615.1 R4014.2
PWR_1D05V_BST: PC5204.1 PU5201.20
PWR_1D05V_EN: PC5215.1 PR5210.2 PU5201.2
PWR_1D05V_FB: PC5212.2 PR5202.2 PR5204.1 PU5201.5
PWR_1D05V_FB_A: PC5212.1 PG5223.1 PR5202.1
PWR_1D05V_PFM#: PR5203.1 PU5201.3
PWR_1D05V_PH: PC5204.2 PL5201.1 PU5201.10 PU5201.11 PU5201.16 PU5201.17 PU5201.18
PWR_1D05V_SS: PC5213.1 PU5201.22
PWR_1D05V_TON: PR5201.2 PU5201.6
PWR_1D8V: PC5302.1 PC5303.1 PC5305.1 PG5303.1 PG5304.1 PG5305.1 PL5301.2 PR5305.1
PWR_1D8V_EN: PC5307.1 PR5308.1 PU5301.7
PWR_1D8V_FB: PC5305.2 PR5304.1 PR5305.2 PU5301.1
PWR_1D8V_PG: PR5210.1 PR5306.2 PU5301.2
PWR_1D8V_PH: PL5301.1 PU5301.6
PWR_1D8V_VIN: PC5301.1 PG5301.2 PG5302.2 PU5301.3
PWR_1D35V_BOOT: PR8633.1 PU8602.1
PWR_1D35V_BOOT_R: PC8619.1 PR8633.2
PWR_1D35V_BYP: PC8618.1 PC8633.1 PR8634.1 PU8602.15
PWR_1D35V_IMAX: PR8632.2 PU8602.13
PWR_1D35V_LDO_P5: PC8617.1 PU8602.16 PU8602.17
PWR_1D35V_PGOOD: PR8611.2 PR8630.2 PU8602.9 PU8602.10
PWR_1D35V_PHASE: PC8619.2 PL8603.1 PU8602.6 PU8602.19 PU8602.20
PWR_1D35V_VFB: PC8602.2 PR8626.1 PR8627.2 PU8602.14
PWR_1D35V_VFB1: PC8602.1 PG8613.2 PR8627.1
PWR_1V_VGA: PC8628.1 PC8631.1 PC8632.1 PG8608.1 PG8622.1 PL8602.2 PR8613.1
PWR_1V_VGA_FB: PC8632.2 PR8613.2 PR8620.1 PU8603.1
PWR_1V_VGA_LX: PL8602.1 PU8603.6
PWR_1V_VGA_VIN: PC8627.1 PC8629.1 PC8630.1 PC8634.1 PG8605.2 PU8603.3
PWR_2D5V: PC5111.1 PC5112.1 PC5113.1 PR5119.1 PR5121.2 PR5122.2 PU5101.3 PU5101.4
PWR_2D5V_EN: PC5127.1 PR5109.1 PR5117.1 PU5101.8
PWR_2D5V_FB: PC5111.2 PR5119.2 PR5120.1 PU5101.2
PWR_2D5V_PG: PG5122.1 PR5112.2 PU5101.7
PWR_3D3V_BOOT: PR4501.1 PU4501.1
PWR_3D3V_BOOT_A: PC4506.1 PR4501.2
PWR_3D3V_EN: PC4508.1 PR4508.1 PR4509.2 PU4501.11
PWR_3D3V_EN1: PC4532.1 PR4514.1 PR4516.2 PU4501.12
PWR_3D3V_FB: PC4533.1 PU4501.13
PWR_3D3V_FB2: PC4533.2 PR4506.2
PWR_3D3V_LDO: PC4507.1 PG4532.1 PU4501.16 PU4501.17
PWR_3D3V_PH: PC4506.2 PL4501.1 PU4501.6 PU4501.19 PU4501.20
PWR_3D3V_VOUT: PG4530.1 PR4506.1 PU4501.14
PWR_5V_BOOT: PR4502.1 PU4502.1
PWR_5V_BOOT_A: PC4521.1 PR4502.2
PWR_5V_EN: PC4530.1 PR4511.2 PR4512.1 PU4502.11
PWR_5V_EN1: PC4531.1 PR4504.2 PR4513.1 PU4502.12
PWR_5V_FB: PC4526.1 PR4551.1 PU4502.13
PWR_5V_FB_A: PC4526.2 PR4507.1
PWR_5V_LDO: PC4520.1 PG4528.1 PU4502.15
PWR_5V_PH: PC4521.2 PL4502.1 PU4502.6 PU4502.19 PU4502.20
PWR_5V_VCC: PC4524.1 PU4502.16 PU4502.17
PWR_5V_VOUT: PG4527.1 PR4507.2 PU4502.14
PWR_BD_DET#: AFTP6408.1 CPU1.CR14 PWR1.6 R2061.2
PWR_CHG_ACIN: PR4484.2 PR4485.1 PU4401.19
PWR_CHG_ACOK: PG4408.1 PR4426.1 PR4429.2 PR4463.2 PR4499.2 PU4401.24
PWR_CHG_ADP/ACIN: PR4434.1 PR4437.1 PU4401.16
PWR_CHG_AIN: PD4408.3 PR4404.1 PR4465.2
PWR_CHG_AIN_R: PC4420.2 PR4404.2 PR4406.1 PR4437.2 PR4484.1
PWR_CHG_AMON: PR4412.2 PU4401.29
PWR_CHG_ASGATE: PR4490.2 TP4401.1
PWR_CHG_ASGATE22: PC4442.2 PR4445.1
PWR_CHG_ASGATE/NTC: PR4490.1 PR4491.2 PU4401.13
PWR_CHG_BATGONE: PC4430.1 PR4409.1 PU4401.25
PWR_CHG_BGATE: PC4429.1 PR4443.1 PU4412.4
PWR_CHG_BGATE/HG2: PC4445.2 PR4443.2 PU4401.32
PWR_CHG_BGATE_22: PD4409.K PR4464.1 PR4495.1
PWR_CHG_BGATE_22_R: PC4443.2 PR4494.1 PR4495.2 PU4413.4
PWR_CHG_BOOT1: PR4402.2 PU4401.12
PWR_CHG_BOOT2: PC4423.1 PU4401.4
PWR_CHG_BT1_R: PC4436.2 PR4402.1
PWR_CHG_BT2_R: PC4423.2 PR4444.2
PWR_CHG_CMRSC: PC4442.1 PR4438.1 PR4439.2
PWR_CHG_COMP: PC4433.1 PR4411.1 PU4401.28
PWR_CHG_COMP_R: PC4431.1 PR4411.2
PWR_CHG_CSIN: PC4415.1 PC4417.2 PR4489.2 PU4401.14
PWR_CHG_CSIN_R: PG4402.2 PR4423.1
PWR_CHG_CSIN_RR: PR4423.2 PR4489.1
PWR_CHG_CSIP: PC4415.2 PC4416.2 PR4488.2 PU4401.15
PWR_CHG_CSIP_R: PG4401.2 PR4422.1
PWR_CHG_CSIP_RR: PR4422.2 PR4488.1
PWR_CHG_CSON: PC4425.2 PC4426.2 PR4487.1 PU4401.1
PWR_CHG_CSON_R: PG4406.2 PR4425.1
PWR_CHG_CSON_RR: PR4425.2 PR4487.2
PWR_CHG_CSOP: PC4424.2 PC4425.1 PR4486.1 PU4401.2
PWR_CHG_CSOP_R: PG4405.2 PR4424.1
PWR_CHG_CSOP_RR: PR4424.2 PR4486.2
PWR_CHG_DCIN: PC4419.1 PR4403.1 PU4401.17
PWR_CHG_DCIN_R: PD4401.3 PD4407.K PR4403.2
PWR_CHG_HG1_R: PR4414.2 PU4403.4
PWR_CHG_HG2_R: PR4420.2 PU4405.4
PWR_CHG_LGATE1: PU4401.9 PU4404.4
PWR_CHG_LGATE2: PR4446.1 PU4406.4
PWR_CHG_LGATE2/ASGATE: PR4445.2 PR4446.2 PU4401.7
PWR_CHG_NGATE: PC4439.2 PR4453.2 PR4480.1 PU4401.3
PWR_CHG_NTC: PR4491.1 PR4492.1
PWR_CHG_OTGEN: PR4417.2 PR4449.2 PR4451.1 PU4401.20
PWR_CHG_OTGPG: PR4447.1 PR4448.2 PU4401.26 TP4411.1
PWR_CHG_PHASE1: PC4436.1 PL4401.1 PL4402.1 PR4416.1 PU4401.10 PU4403.1 PU4403.2 PU4403.3 PU4404.5 PU4404.6 PU4404.7 PU4404.8
PWR_CHG_PHASE2: AFTP4405.1 PG4423.1 PL4401.2 PL4402.2 PR4441.1 PU4405.1 PU4405.2 PU4405.3 PU4406.5 PU4406.6 PU4406.7 PU4406.8
PWR_CHG_PHASE2_R: PR4441.2 PR4444.1 PU4401.6
PWR_CHG_PROCHOT#: PQ4416.2 PR4435.2 PU4401.23
PWR_CHG_PROCHOT#_R: PQ4402.G PQ4416.5 PQ4416.6 PR4472.2
PWR_CHG_PROG: PC4441.1 PR4410.2 PR4493.1 PU4401.27
PWR_CHG_PSYS: PR4413.1 PR4442.1 PU4401.30
PWR_CHG_SNB: PC4435.1 PR4416.2
PWR_CHG_UGATE1: PR4414.1 PU4401.11
PWR_CHG_UGATE2: PR4420.1 PR4438.2 PU4401.5
PWR_CHG_VBAT1: PC4440.2 PC4445.1 PR4478.1 PU4401.31
PWR_CHG_VBATIN: AFTP4401.1 PG4406.1 PG4422.1 PR4407.2 PU4412.1 PU4412.2 PU4412.3
PWR_CHG_VBATIN_R: AFTP4404.1 AFTP4406.1 PG4405.1 PG4415.1 PG4423.2 PR4407.1 PR4480.2 PU4413.5 PU4413.6 PU4413.7 PU4413.8
PWR_CHG_VDDP: PC4421.1 PR4405.1 PU4401.8
PWR_DCBATOUT_1D05V: PC5209.1 PC5210.1 PC5211.1 PC5214.1 PC5216.1 PG5210.2 PG5212.2 PG5214.2 PR5201.1 PU5201.7 PU5201.8 PU5201.9
PWR_DCBATOUT_1D35V: PC8609.1 PC8610.1 PC8615.1 PG8614.2 PG8615.2 PG8616.2 PG8617.2 PU8602.2 PU8602.3 PU8602.4 PU8602.5
PWR_DCBATOUT_VCCGTA: PC4802.1 PC4803.1 PC4804.1 PC4805.1 PC4814.1 PC4815.1 PC4816.1 PC4817.1 PL4803.2 PL4804.2 PT4807.1 PT4808.1 PU4801.8 PU4801.9 PU4801.10 PU4801.11 PU4801.33 PU4802.8 PU4802.9 PU4802.10 PU4802.11 PU4802.33
PWR_DCBATOUT_VCCSA: AFTP5001.1 PC5002.1 PC5003.1 PC5004.1 PG5002.1 PG5003.1 PU5002.5 PU5002.6 PU5002.7 PU5002.8
PWR_DCBATOUT_VCORE: PC4701.1 PC4702.1 PC4703.1 PC4704.1 PL4702.2 PL4703.2 PT4702.1 PU4701.8 PU4701.9 PU4701.10 PU4701.11 PU4701.33
PWR_DCBATOUT_VDDQ: PC5115.1 PC5119.1 PC5122.1 PD5101.K PG5101.2 PG5102.2 PG5104.2 PR5106.1 PU5102.21 PU5102.22 PU5102.23 PU5102.24 PU5102.34
PWR_LED#: Q6402.S R6412.1 U2402.4
PWR_LED#_C: AFTP6407.1 PWR1.4 R6410.2
PWR_LED#_Q: Q6402.D Q6405.B R6412.2
PWR_LED#_R: EC6405.1 Q6405.C R6410.1
PWR_LEVEL: D7902.A GPU1.D7 R7905.2
PWR_VCCGT_BOOTA: PR4804.2 PU4801.5
PWR_VCCGT_BOOTA_RC: PC4808.1 PR4804.1
PWR_VCCGT_BOOTB: PR4810.2 PU4802.5
PWR_VCCGT_BOOTB_RC: PC4811.1 PR4810.1
PWR_VCCGT_BOOTRA: PC4808.2 PU4801.7
PWR_VCCGT_BOOTRB: PC4811.2 PU4802.7
PWR_VCCGT_COMP: PC4610.2 PR4626.2 PU4601.4
PWR_VCCGT_COMP1: PC4612.1 PC4651.1 PR4626.1
PWR_VCCGT_FB: PR4630.2 PR4633.2 PR4636.2 PU4601.5
PWR_VCCGT_FB1: PC4614.1 PR4630.1
PWR_VCCGT_FB2: PC4615.2 PC4618.2 PC4619.1 PR4631.1 PR4633.1 PR4665.2
PWR_VCCGT_FB_RC: PC4618.1 PR4636.1
PWR_VCCGT_FCCM#: PR4806.2 PR4812.2 PU4601.11
PWR_VCCGT_FCCM#_RA: PR4806.1 PU4801.2
PWR_VCCGT_FCCM#_RB: PR4812.1 PU4802.2
PWR_VCCGT_IMON: PC4604.2 PR4608.2 PU4601.2
PWR_VCCGT_ISEN1: PC4625.1 PR4669.2 PR4821.1 PR4824.2 PU4601.9
PWR_VCCGT_ISEN2: PC4626.1 PR4669.1 PR4670.1 PR4822.2 PR4823.1 PU4601.10
PWR_VCCGT_ISUMN: AFTP4603.1 PC4625.2 PC4626.2 PC4630.2 PC4633.1 PR4642.2 PR4643.2 PR4645.2 PR4646.2 PR4647.1 PR4809.2 PR4815.2
PWR_VCCGT_ISUMN_GA: PG4809.1 PR4809.1 PR4822.1
PWR_VCCGT_ISUMN_GB: PG4815.1 PR4815.1 PR4824.1
PWR_VCCGT_ISUMN_P_1: PC4628.2 PC4653.2 PC4654.2 PR4647.2
PWR_VCCGT_ISUMN_P_2: AFTP4604.1 PR4641.2 PR4646.1
PWR_VCCGT_ISUMN_RC: PC4623.1 PR4645.1
PWR_VCCGT_ISUMNB: PC4623.2 PR4642.1 PU4601.8
PWR_VCCGT_ISUMP: PC4628.1 PC4630.1 PC4653.1 PC4654.1 PR4641.1 PR4643.1 PR4808.1 PR4816.1 PU4601.7
PWR_VCCGT_ISUMP_GA: PG4808.1 PR4808.2 PR4821.2
PWR_VCCGT_ISUMP_GB: PG4813.1 PR4816.2 PR4823.2
PWR_VCCGT_NTC: PR4616.1 PU4601.3
PWR_VCCGT_NTC1: PR4616.2 PR4617.1 PR4621.2
PWR_VCCGT_PWMA: PR4802.2 PU4601.12
PWR_VCCGT_PWMA_RA: PR4802.1 PU4801.1
PWR_VCCGT_PWMB: PR4811.2 PU4601.13
PWR_VCCGT_PWMB_RA: PR4811.1 PU4802.1
PWR_VCCGT_RTN: PC4619.2 PC4622.1 PR4639.1 PR4666.2 PU4601.6
PWR_VCCGT_SNB1: PC4810.1 PR4805.2
PWR_VCCGT_SNB2: PC4813.1 PR4814.2
PWR_VCCGT_SWA: PG4808.2 PL4801.1 PR4805.1 PU4801.16 PU4801.17 PU4801.18 PU4801.19 PU4801.20 PU4801.21 PU4801.22 PU4801.23 PU4801.24 PU4801.25 PU4801.26
PWR_VCCGT_SWB: PG4813.2 PL4802.1 PR4814.1 PU4802.16 PU4802.17 PU4802.18 PU4802.19 PU4802.20 PU4802.21 PU4802.22 PU4802.23 PU4802.24 PU4802.25 PU4802.26
PWR_VCCGT_VCCDA: PC4809.1 PR4803.1 PU4801.3
PWR_VCCGT_VCCDB: PC4812.1 PR4813.1 PU4802.3
PWR_VCCSA_BST: PR5001.2 PU5001.2
PWR_VCCSA_BST_RC: PC5005.1 PR5001.1
PWR_VCCSA_COMP: PC4624.1 PR4640.1 PU4601.24
PWR_VCCSA_COMP_RC: PC4601.1 PR4640.2
PWR_VCCSA_DRVH: PU5001.1 PU5002.4
PWR_VCCSA_DRVL: PU5001.5 PU5003.4
PWR_VCCSA_FB: PR4632.2 PR4637.1 PR4638.2 PU4601.25
PWR_VCCSA_FB1: PC4621.2 PR4638.1
PWR_VCCSA_FB2: PC4616.2 PC4617.2 PC4620.1 PR4601.1 PR4637.2
PWR_VCCSA_FB_RC: PC4617.1 PR4632.1
PWR_VCCSA_FCCM: PU4601.29 PU5001.7
PWR_VCCSA_IMON: PC4629.2 PR4644.1 PU4601.23
PWR_VCCSA_ISUMN: AFTP4605.1 PC4603.2 PC4605.1 PR4611.1 PR4613.1 PR4615.1 PR4618.2 PR4620.1 PR5004.2
PWR_VCCSA_ISUMN_P_1: PC4608.2 PR4613.2
PWR_VCCSA_ISUMN_P_2: AFTP4606.1 PR4611.2 PR4625.2
PWR_VCCSA_ISUMN_R: PG5001.1 PR5004.1
PWR_VCCSA_ISUMN_RC: PC4611.1 PR4615.2
PWR_VCCSA_ISUMNB: PC4611.2 PR4620.2 PU4601.28
PWR_VCCSA_ISUMP: PC4605.2 PC4608.1 PR4618.1 PR4625.1 PR5003.2 PU4601.27
PWR_VCCSA_ISUMP_R: PG5011.1 PR5003.1
PWR_VCCSA_PWM: PU4601.30 PU5001.3
PWR_VCCSA_RTN: PC4613.1 PC4616.1 PR4602.1 PR4627.2 PU4601.26
PWR_VCCSA_SW: PC5005.2 PG5011.2 PL5001.1 PU5001.8 PU5002.1 PU5002.2 PU5002.3 PU5003.5 PU5003.6 PU5003.7 PU5003.8
PWR_VCORE_BOOT: PR4705.2 PU4701.5
PWR_VCORE_BOOT_RC: PC4707.1 PR4705.1
PWR_VCORE_BOOTR: PC4707.2 PU4701.7
PWR_VCORE_COMP: PC4639.1 PR4656.1 PU4601.16
PWR_VCORE_COMP1: PC4640.1 PR4656.2
PWR_VCORE_FB: PR4657.1 PR4658.1 PR4660.1 PU4601.17
PWR_VCORE_FB1: PC4641.1 PR4657.2
PWR_VCORE_FB2: PC4642.2 PC4643.2 PC4644.1 PR4660.2 PR4663.2 PR4667.2
PWR_VCORE_FB_RC: PC4643.1 PR4658.2
PWR_VCORE_FCCM#: PR4706.2 PU4601.21
PWR_VCORE_FCCM#_R: PR4706.1 PU4701.2
PWR_VCORE_IMON: PC4638.1 PR4661.1 PU4601.14
PWR_VCORE_ISUMN: AFTP4601.1 PC4631.1 PC4634.1 PR4648.2 PR4649.2 PR4650.1 PR4651.2 PR4652.2 PR4701.2
PWR_VCORE_ISUMN_G: PG4708.1 PR4701.1
PWR_VCORE_ISUMN_P_1: PC4635.1 PC4652.1 PR4649.1
PWR_VCORE_ISUMN_P_2: AFTP4602.1 PR4650.2 PR4653.2
PWR_VCORE_ISUMN_RC: PC4632.1 PR4651.1
PWR_VCORE_ISUMNA: PC4632.2 PR4648.1 PU4601.20
PWR_VCORE_ISUMP: PC4634.2 PC4635.2 PC4652.2 PR4652.1 PR4653.1 PR4708.2 PU4601.19
PWR_VCORE_ISUMP_G: PG4707.1 PR4708.1
PWR_VCORE_NTC: PR4662.1 PU4601.15
PWR_VCORE_NTC1: PR4654.1 PR4655.2 PR4662.2
PWR_VCORE_PROG1: PR4629.1 PU4601.32
PWR_VCORE_PROG2: PR4628.1 PU4601.31
PWR_VCORE_PWM: PR4702.2 PU4601.22
PWR_VCORE_PWM_R: PR4702.1 PU4701.1
PWR_VCORE_RTN: PC4637.1 PC4642.1 PR4659.2 PR4668.2 PU4601.18
PWR_VCORE_SNB: PC4706.1 PR4703.2
PWR_VCORE_SW: PG4707.2 PL4701.1 PR4703.1 PU4701.16 PU4701.17 PU4701.18 PU4701.19 PU4701.20 PU4701.21 PU4701.22 PU4701.23 PU4701.24 PU4701.25 PU4701.26
PWR_VCORE_VCC: PC4607.1 PR4610.2 PU4601.34
PWR_VCORE_VCC_R: PC4708.1 PR4704.1 PU4701.3
PWR_VCORE_VIN: PC4606.1 PR4612.2 PU4601.33
PWR_VCORE_VR: PR4614.1 PR4671.1 PU4601.1
PWR_VCORE_VRHOT#: PR4607.2 PU4601.38
PWR_VDDQ: PC5104.1 PC5105.1 PC5106.1 PC5107.1 PG5103.1 PG5105.1 PG5106.1 PG5107.1 PG5108.1 PG5109.1 PG5111.2 PL5101.2
PWR_VDDQ_BOOT: PR5105.1 PU5102.27
PWR_VDDQ_BOOTA: PC5102.2 PR5105.2
PWR_VDDQ_BOOTB: PC5102.1 PU5102.25
PWR_VDDQ_CS: PR5102.2 PU5102.10
PWR_VDDQ_EN: PG5122.2 PR5114.1 PU5102.6
PWR_VDDQ_FB: PR5103.2 PR5104.1 PU5102.3
PWR_VDDQ_PG: PG5114.2 PR5101.2 PU5102.8
PWR_VDDQ_PH: PL5101.1 PR5110.1 PU5102.17 PU5102.18 PU5102.19 PU5102.20 PU5102.35
PWR_VDDQ_SNB: PC5118.1 PR5110.2
PWR_VDDQ_TON: PR5106.2 PU5102.7
PWR_VDDQ_VCC: PC5103.1 PR5102.1 PR5108.2 PU5102.9
PWR_VDDQ_VDDQ: PG5111.1 PR5103.1 PU5102.2
PWR_VDDQ_VLDOIN: PC5114.1 PG5110.2 PG5116.2 PU5102.28
PWR_VDDQ_VTTREF: PC5123.1 PU5102.1
PWR_VGA_CORE_EN#: Q8705.5 Q8705.6 R8710.1
PWR_VGA_CORE_PSI: PC8556.1 PR8522.2 PR8563.2 PR8564.1 PU8514.4
PWR_VGA_CORE_VID: PC8552.2 PR8510.2 PU8514.5
PWR_VGA_GDDR_EN: C8803.1 PU8602.11 Q8702.2 R8604.1 R8807.2
PWR_VGA_GDDR_EN_L: R8807.1 U8803.4
PWR_VGA_NVDD_SS: PC8573.1 PR8512.1 PR8513.1 PR8573.1
PWR_VGA_NVVDD_BOOT1: PR8572.1 PU8514.1
PWR_VGA_NVVDD_BOOT1_A: PC8572.1 PR8572.2
PWR_VGA_NVVDD_BOOT2: PR8574.1 PU8514.15
PWR_VGA_NVVDD_BOOT2_A: PC8575.1 PR8574.2
PWR_VGA_NVVDD_EN: PR8526.1 Q8705.2 U8804.4
PWR_VGA_NVVDD_EN_R: PR8526.2 PU8514.3
PWR_VGA_NVVDD_HG1: PU8510.1 PU8512.1 PU8514.2
PWR_VGA_NVVDD_HG2: PU8514.14 PU8515.1 PU8516.1
PWR_VGA_NVVDD_LGATE1: PR8508.1 PU8510.8 PU8512.8 PU8514.19
PWR_VGA_NVVDD_LGATE2: PU8514.17 PU8515.8 PU8516.8
PWR_VGA_NVVDD_PG: PR8530.2 PU8514.13 U7302.1
PWR_VGA_NVVDD_PHASE1: PC8572.2 PL8508.1 PR8501.1 PU8510.9 PU8512.9 PU8514.20
PWR_VGA_NVVDD_PHASE2: PC8575.2 PL8509.1 PR8502.1 PU8514.16 PU8515.9 PU8516.9
PWR_VGA_NVVDD_PVCC: PC8550.1 PR8551.2 PU8514.18
PWR_VGA_NVVDD_REFADJ: PR8558.2 PU8514.6
PWR_VGA_NVVDD_REFADJ_R: PC8555.1 PR8556.2 PR8557.2 PR8558.1
PWR_VGA_NVVDD_REFIN: PC8554.1 PR8557.1 PR8559.2 PU8514.7
PWR_VGA_NVVDD_REFIN_R: PR8559.1 PR8560.2
PWR_VGA_NVVDD_TON: PR8553.2 PU8514.9
PWR_VGA_NVVDD_TON_1: PC8551.2 PR8552.2 PR8553.1
PWR_VGA_NVVDD_VREF: PC8553.2 PR8556.1 PU8514.8
PWR_VGA_NVVDD_VSEN: PC8558.1 PC8559.1 PR8503.2 PR8504.2 PR8517.1 PR8576.1
PWR_VGA_NVVDD_VSEN_N: PC8553.1 PC8554.2 PC8555.2 PC8558.2 PC8560.1 PR8505.1 PR8520.1 PR8560.1 PU8514.10
PWR_VGA_NVVDD_VSEN_P: PR8503.1 PR8512.2 PU8514.12
PWR_VGA_NVVDD_VSNS/SS: PR8513.2 PR8576.2 PU8514.11
PWR_VGA_SNUB1: PC8507.1 PR8501.2
PWR_VGA_SNUB2: PC8508.1 PR8502.2
Q501_G: Q501.D Q502.G R506.2
Q5503_B: Q5502.B R5554.2
Q5503_C: Q5502.C R5546.1
Q5503_E: Q5502.E R5551.1
Q5504_B: Q5501.B R5553.2
Q5504_C: Q5501.C R5548.1
Q5505_E: Q5501.E R5550.1
Q6205_Q: Q6503.D R6503.2
Q6407_B: Q6407.1 Q6408.C R6405.1
Q6407_C: Q6407.3 R6413.2
REGOUT: C3118.1 R3101.1 U3101.24
RESET_OUT#: C2614.1 CPU1.BP31 ED1705.2 Q2602.G R2616.2 RN1703.3(B) U2401.73
REXT1: R5804.1 U5802.20
RING2_HPMIC1: ED2911.2 HPMIC1.3 R2906.2
RSET: R3102.1 U3101.31
RSMRST_PWRGD#: D4002.K R4029.2 R4030.2 R4031.2 R4033.2
RTC_3P3_EN_G: Q2510.D R2506.1
RTC_DET#: CPU1.CP22 Q2505.D R1554.2
RTC_RST#: C1806.1 CPU1.BR34 ED1802.2 G1801.2 RN1801.4(B)
RTCRST_ON: D2502.K Q2507.G R2518.1 R2567.1 U2401.31
RUNPWROK: D4002.A D4003.A ED1706.2 R1716.1 R4002.1 R4005.2 R4011.2 U2401.48
SA0_CHA_DIM0: DM1.256 R1204.1 R1205.1
SA0_CHB_DIM0: DM2.256 R1302.1 R1303.1
SA1_CHA_DIM0: DM1.260 R1208.1 R1210.1
SA1_CHB_DIM0: DM2.260 R1306.1 R1307.1
SA2_CHA_DIM0: DM1.166 R1211.1 R1212.1
SA2_CHB_DIM0: DM2.166 R1310.1 R1311.1
SATA1_ODD_PRSNT#: CPU1.CM10 R1617.2 R6004.1
SATA_LED#: CPU1.CN7 D6401.1 R1606.2
SATA_LED#_D: D6401.3 Q6401.S R6415.2
SATA_ODD_DA#_C: ODD1.16 TP6001.1
SATA_ODD_PRSNT#_R: AFTP6005.1 ODD1.7 R6004.2
SD_RCOMP: CPU1.CK33 CPU1.CM34 R1901.1
SD_READ_MODE#: AFTP6610.1 CPU1.CA30 R6601.1
SD_READ_MODE#_R: IOBD1.3 R6601.2
SIO_EXT_SMI#: CPU1.CP7 R407.1
SIO_EXT_WAKE#: CPU1.CN12 R2041.2 U2401.116
SIO_PWRBTN#: CPU1.BU28 TP1706.1 U2401.52
SIO_RCIN#: CPU1.BV29 R1820.2
SIO_SLP_A#: CPU1.BU37 TP1705.1
SIO_SLP_S0#: CPU1.BJ37 R1739.1 R4040.1 R9121.2
SIO_SLP_S3#: C1703.1 CPU1.BU36 D4003.K R4017.1 U4001.3 U4004.3 U4004.5 U4007.1
SIO_SLP_S4#: C1702.1 CPU1.BU27 PR5117.2 Q9202.G R4024.1
SIO_SLP_S5#: CPU1.BT29 TP1702.1
SKTOCC#: CPU1.E1 TP619.1
SLEEVE_R: ED2912.1 HPMIC1.4 R2911.2
SM_DRAMRST#_CPU: CPU1.BU31 R504.1 R505.2
SM_INTRUDER#: CPU1.BR35 R1730.2
SM_PGCNTL: CPU1.C35 Q501.G
SM_PGCNTL_Q: PU5102.5 Q502.D R507.2
SM_RCOMP_0: CPU1.BN28 R501.1
SM_RCOMP_1: CPU1.BN27 R502.1
SM_RCOMP_2: CPU1.BN29 R503.1
SMB_ALERT#: CPU1.CJ15 R1551.2
SMBC_THERM_NV: GPU1.D9 Q7901.4 RN7901.2(A)
SMBD_THERM_NV: GPU1.D8 Q7901.1 RN7901.1(A)
SML0_ALERT#: CPU1.CG15 R1504.2 R1806.1
SML0_SMBCLK: CPU1.CH14 RN1807.6(B)
SML0_SMBDATA: CPU1.CF15 RN1807.7(B)
SML1_SMBCLK: CPU1.CN15 Q2601.3 Q7901.3 R2459.1 RN1811.3(B)
SML1_SMBDATA: CPU1.CM15 Q2601.6 Q7901.6 R2447.1 RN1811.4(B)
SML1ALERT#: CPU1.CC34 R1837.2
SPI_CLK_CPU: R1842.1 R2508.2 R2513.2 R9138.1
SPI_CLK_CPU_R: CPU1.CH37 R1842.2
SPI_CLK_ROM: BIOS1.6 EC2503.1 R2508.1
SPI_CLK_ROM2: BIOS2.6 EC2504.1 R2513.1
SPI_CLK_ROM_TPM: R9138.2 U9103.19
SPI_CS2#_IC: R9130.2 R9148.2 U9103.20
SPI_CS_CPU_N0: BIOS1.1 CPU1.CG36 R2519.2
SPI_CS_CPU_N1: BIOS2.1 CPU1.CG35 R2521.2
SPI_CS_CPU_N2: CPU1.CH34 R9118.2 R9130.1
SPI_HOLD_CPU: R1510.2 R1846.1 R2503.2 R2511.2
SPI_HOLD_CPU_R: CPU1.CG34 R1846.2
SPI_HOLD_ROM: BIOS1.7 R2503.1
SPI_HOLD_ROM2: BIOS2.7 R2511.1
SPI_IRQ#_TPM2: R9119.1 R9151.1 R9152.1 U9103.18
SPI_SI_CPU: R1506.2 R1844.1 R2509.2 R2512.2 R9133.1
SPI_SI_CPU_R: CPU1.CF36 R1844.2
SPI_SI_ROM: BIOS1.5 EC2501.1 R2509.1
SPI_SI_ROM2: BIOS2.5 EC2505.1 R2512.1
SPI_SI_ROM_TPM: R9133.2 U9103.21
SPI_SO_CPU: R1843.1 R2501.1 R2502.1 R9132.1
SPI_SO_CPU_R: CPU1.CF37 R1843.2
SPI_SO_ROM: BIOS1.2 EC2502.1 R2502.2
SPI_SO_ROM2: BIOS2.2 EC2506.1 R2501.2
SPI_SO_ROM_TPM: R9132.2 U9103.24
SPI_WP_CPU: R1508.2 R1845.1 R2507.1 R2510.1
SPI_WP_CPU_R: CPU1.CF34 R1845.2
SPI_WP_ROM: BIOS1.3 R2507.2
SPI_WP_ROM2: BIOS2.3 R2510.2
SPKR: CPU1.CF35 R2740.1
SRTC_RST#: C1805.1 CPU1.BR37 ED1801.2 RN1801.3(B)
SSD2_DEVSLP: CPU1.CR8 R1619.1
SSD_CLK_CPU_N_4: CPU1.BA1 SSD1.53
SSD_CLK_CPU_P_4: CPU1.BA2 SSD1.55
SSD_DEVSLP: CPU1.CM8 R1618.1
SSD_DEVSLP_R: R1618.2 R1619.2 R6301.1
SSD_PCIE_RX_N13: CPU1.BK6 SSD1.5
SSD_PCIE_RX_N14: CPU1.BJ6 SSD1.17
SSD_PCIE_RX_N15: CPU1.BG5 SSD1.29
SSD_PCIE_RX_N16: CPU1.BE5 SSD1.43
SSD_PCIE_RX_P13: CPU1.BK5 SSD1.7
SSD_PCIE_RX_P14: CPU1.BJ5 SSD1.19
SSD_PCIE_RX_P15: CPU1.BG6 SSD1.31
SSD_PCIE_RX_P16: CPU1.BE6 SSD1.41
SSD_PCIE_TX_CON_N13: C6316.1 SSD1.11
SSD_PCIE_TX_CON_N14: C6314.1 SSD1.23
SSD_PCIE_TX_CON_N15: C6312.1 SSD1.35
SSD_PCIE_TX_CON_P13: C6315.1 SSD1.13
SSD_PCIE_TX_CON_P14: C6313.1 SSD1.25
SSD_PCIE_TX_CON_P15: C6311.1 SSD1.37
SSD_PCIE_TX_N13: C6316.2 CPU1.BM4
SSD_PCIE_TX_N14: C6314.2 CPU1.BL2
SSD_PCIE_TX_N15: C6312.2 CPU1.BL4
SSD_PCIE_TX_N16: C6303.2 CPU1.BJ4
SSD_PCIE_TX_P13: C6315.2 CPU1.BM3
SSD_PCIE_TX_P14: C6313.2 CPU1.BL1
SSD_PCIE_TX_P15: C6311.2 CPU1.BL3
SSD_PCIE_TX_P16: C6302.2 CPU1.BJ3
SSD_SATA_TX_CON_N16: C6303.1 SSD1.47
SSD_SATA_TX_CON_P16: C6302.1 SSD1.49
SSD_SCP#: SSD1.8 U2401.21
SSEQ0_A0: R7145.2 R7146.1 U7101.11
SSEQ1: R7144.1 R7152.2 U7101.3
ST_GPIO: TP9103.1 U9103.6
ST_PP: TP9101.1 U9103.7
STRAP0: GPU1.D1 R7908.1 R7919.2
STRAP1: GPU1.D2 R7909.2 R7911.1
STRAP2: GPU1.E4 R7914.2 R7915.1
STRAP3: GPU1.E3 R7926.1 R7977.2
STRAP4: GPU1.D3 R7929.1 R7976.2
STRAP5: GPU1.C1 R7945.2
STRAP5_R: R7939.1 R7945.1 R7978.2
STRAP_REF0_GND_N9: GPU1.F6 R7907.2
SUS_CLK: CPU1.BT32 EC1803.2 R2461.1 R6117.1
SUSACK#_R: CPU1.BY32 R1708.2
SUSCLK_WLAN: R6117.2 WLAN1.50
SVID_ALERT#_CPU: PR4605.2 PR4623.1 R703.1 R704.2
SVID_ALERT#_CPU_R: CPU1.AA3 R703.2
SVID_ALERT#_VR: PR4623.2 PU4601.36
SVID_CLK_CPU: PR4606.2 PR4624.1 R702.2 R705.2
SVID_CLK_CPU_R: CPU1.AA1 R702.1
SVID_CLK_VR: PR4624.2 PU4601.37
SVID_DATA_CPU: PR4604.2 PR4622.1 R701.2 R706.2
SVID_DATA_CPU_R: CPU1.AA2 R701.1
SVID_DATA_VR: PR4622.2 PU4601.35
SW_PIN: R5820.2 U5802.18
SYS_LED_MASK#: Q3201.G Q6402.G Q6406.2 Q6406.5 R2465.1 R2497.1 U2401.55
SYS_PEX_RST_MON#: R7606.1 R7613.1 R7922.2 R7974.2 U7601.4 U7602.2
SYS_PEX_RST_MON_GPU#: GPU1.E9 R7974.1
SYS_PRES1#: AFTP4315.1 BATT1.7 R4301.2
SYS_PWROK: CPU1.CR10 ED1702.2 R1717.1 U2401.28
SYSPWR_PRES: R2454.1 R2463.2 U2401.120
T_CRIT#: R2601.1 R2604.2 U2601.4
TESTMODE: GPU1.AD9 R7602.1
THERM_SYS_SHDN#: Q2602.S R2601.2 R2602.1
THERMTRIP#_CPU: CPU1.BJ1 ED301.1 R308.2
TOP_MUX_N: ED7311.2 EL7105.3 JUSB1.A7 R7333.2
TOP_MUX_N_L: EL7105.4 R7131.2 U7102.17
TOP_MUX_P: ED7312.2 EL7105.2 JUSB1.A6 R7332.2
TOP_MUX_P_L: EL7105.1 R7132.2 U7102.18
TOUCH_I2C_DET#: AFTP5501.1 CPU1.CC29 LCD1.12 R2062.2
TOUCH_PAD_INTR#: CPU1.CB34 R319.2
TOUCH_PANEL_INTR#: CPU1.CN3 R5533.1 R5544.2
TOUCH_PANEL_PD#: AFTP5503.1 CPU1.CC35 LCD1.14
TOUCH_REPORT_SW: AFTP5514.1 D2402.A LCD1.26
TOUCH_USB20_N: CPU1.CH5 R5511.1
TOUCH_USB20_N_R: ED5502.4 LCD1.28 R5511.2
TOUCH_USB20_P: CPU1.CH6 R5512.1
TOUCH_USB20_P_R: ED5502.3 LCD1.27 R5512.2
TP_EN#: R2499.2 R6504.1 U2401.49
TP_ON#_GATE: C6502.2 Q6502.G Q6503.G R6504.2
TP_VDD: AFTP6529.1 C6505.1 Q6502.D R6502.2 R6503.1 R6511.2 RN6501.1(A) RN6501.2(A) RN6503.1(A) RN6503.2(A) TP1.8
TP_WAKE_KBC#: AFTP6525.1 R319.1 R6511.1 TP1.4 U2401.33
TPAN_VDD_EN_R: R5559.2 R5560.2 R5564.1 U5503.5
TPCLK_C: AFTP6530.1 RN6502.4(B) TP1.1
TPDATA_C: AFTP6524.1 RN6502.3(B) TP1.2
TPM_GPIO0: R9121.1 U9103.29
TPM_GPIO1: TP9102.1 U9103.30
TPM_GPIO4: R9118.1 U9103.13
TPM_ID: CPU1.CK25 R1910.2 R1911.1
TPM_SPI_IRQ#: CPU1.CF20 R9151.2
TPS2544_FAULT#: R3607.1 U3601.13
TPS70933_EN: Q7201.D R7217.2 R7218.1 U7203.4
TPS70933_EN_G: C7215.2 Q7201.G R7216.2
TS#_DIMM0_1: DM1.134 R1215.2
TS#_DIMM1_1: DM2.134 R1312.2
TS_INT#: AFTP5502.1 LCD1.13 R5533.2
TS_VREF: GPU1.AE2 TP7701.1
TYPEC_DCIN1_EN#: Q7406.2 Q7407.2 R2491.1 R7428.1 U2401.63
TYPEC_DP_AUXN: R7104.1 U5802.27
TYPEC_DP_AUXP: R7103.1 U5802.26
TYPEC_DP_N0: C7113.1 U5802.49
TYPEC_DP_N0_C: C7113.2 R7178.1
TYPEC_DP_N1: C7107.1 U5802.46
TYPEC_DP_N1_C: C7107.2 R7180.1
TYPEC_DP_N2: C7108.1 U5802.44
TYPEC_DP_N2_C: C7108.2 R7182.1
TYPEC_DP_N3: C7110.1 U5802.41
TYPEC_DP_N3_C: C7110.2 R7184.1
TYPEC_DP_P0: C7112.1 U5802.50
TYPEC_DP_P0_C: C7112.2 R7177.1
TYPEC_DP_P1: C7114.1 U5802.47
TYPEC_DP_P1_C: C7114.2 R7179.1
TYPEC_DP_P2: C7109.1 U5802.45
TYPEC_DP_P2_C: C7109.2 R7181.1
TYPEC_DP_P3: C7111.1 U5802.42
TYPEC_DP_P3_C: C7111.2 R7183.1
TYPEC_SMBCLK: Q2417.1 RN2413.4(B) U2401.91 U7102.3
TYPEC_SMBDA: Q2417.4 RN2413.3(B) U2401.89 U7102.4
U9101_2_GND: R9101.2 U9103.2
UART_2_CRXD_DTXD: CPU1.CR12 R2048.2 R6803.1
UART_2_CRXD_DTXD_CON: DBG1.14 R6803.2
UART_2_CTXD_DRXD: CPU1.CP12 R2049.2 R6802.1
UART_2_CTXD_DRXD_CON: DBG1.13 R6802.2
USB1_SBU1: AFTP7101.1 ED7307.2 JUSB1.A8 R7331.2 U7101.27
USB1_SBU2: AFTP7102.1 ED7307.1 JUSB1.B8 R7330.2 U7101.26
USB1_SSRX_CMC_N1: C7169.1 U7101.31
USB1_SSRX_CMC_N1_C: C7169.2 R7120.1 R7187.1
USB1_SSRX_CMC_N2: C7167.1 U7101.39
USB1_SSRX_CMC_N2_C: C7167.2 R7123.1 R7185.1
USB1_SSRX_CMC_P1: C7168.1 U7101.30
USB1_SSRX_CMC_P1_C: C7168.2 R7119.1 R7186.1
USB1_SSRX_CMC_P2: C7170.1 U7101.40
USB1_SSRX_CMC_P2_C: C7170.2 R7122.1 R7188.1
USB1_SSRX_CON_N1: ED7301.4 ED7301.7 JUSB1.B10 R7120.2
USB1_SSRX_CON_N2: ED7302.2 ED7302.9 JUSB1.A10 R7123.2
USB1_SSRX_CON_P1: ED7301.5 ED7301.6 JUSB1.B11 R7119.2
USB1_SSRX_CON_P2: ED7302.1 ED7302.10 JUSB1.A11 R7122.2
USB1_SSTX_C_N1: C7163.2 U7101.34
USB1_SSTX_C_N2: C7162.2 U7101.36
USB1_SSTX_C_P1: C7164.2 U7101.33
USB1_SSTX_C_P2: C7161.2 U7101.37
USB1_SSTX_CMC_N1: C7163.1 R7117.1
USB1_SSTX_CMC_N2: C7162.1 R7125.1
USB1_SSTX_CMC_P1: C7164.1 R7115.1
USB1_SSTX_CMC_P2: C7161.1 R7124.1
USB1_SSTX_CON_N1: ED7301.1 ED7301.10 JUSB1.A3 R7117.2
USB1_SSTX_CON_N2: ED7302.5 ED7302.6 JUSB1.B3 R7125.2
USB1_SSTX_CON_P1: ED7301.2 ED7301.9 JUSB1.A2 R7115.2
USB1_SSTX_CON_P2: ED7302.4 ED7302.7 JUSB1.B2 R7124.2
USB1_USB20_N: CPU1.CD3 R7134.1 U7102.2
USB1_USB20_N_R: R7131.1 R7134.2
USB1_USB20_P: CPU1.CD4 R7133.1 U7102.1
USB1_USB20_P_R: R7132.1 R7133.2
USB2_ID: CPU1.CE8 RN1602.1(A)
USB2_USB20_N: CPU1.CE1 EL6602.4 R6606.1
USB2_USB20_N_CMC: ED6601.3 EL6602.3 IOBD1.8 R6606.2
USB2_USB20_P: CPU1.CE2 EL6602.1 R6607.1
USB2_USB20_P_CMC: ED6601.4 EL6602.2 IOBD1.9 R6607.2
USB2_VBUSSENSE: CPU1.CC6 RN1602.2(A)
USB3_CHAR_2544_N: R3615.1 U3601.11
USB3_CHAR_2544_P: R3614.1 U3601.10
USB3_CHAR_N: EL3501.4 R3615.2 R3617.2
USB3_CHAR_P: EL3501.1 R3614.2 R3616.2
USB3_NONPS_N: R3611.2 R3617.1
USB3_NONPS_P: R3610.2 R3616.1
USB3_USB20_2544_N: R3613.1 U3601.2
USB3_USB20_2544_P: R3612.1 U3601.3
USB3_USB20_CON_N: AFTP3502.1 ED3502.1 EL3501.3 USB1.2
USB3_USB20_CON_P: AFTP3503.1 ED3502.6 EL3501.2 USB1.3
USB3_USB20_N: CPU1.CE3 R3611.1 R3613.2
USB3_USB20_P: CPU1.CE4 R3610.1 R3612.2
USB3_USB30_RX_CON_N: ED3501.1 ED3501.10 EL3503.3 R3508.1 USB1.5
USB3_USB30_RX_CON_P: ED3501.2 ED3501.9 EL3503.4 R3502.1 USB1.6
USB3_USB30_TX_CMC_N: C3521.2 EL3502.1 R3507.2
USB3_USB30_TX_CMC_P: C3520.2 EL3502.2 R3501.2
USB3_USB30_TX_CON_N: ED3501.4 ED3501.7 EL3502.3 R3507.1 USB1.8
USB3_USB30_TX_CON_P: ED3501.5 ED3501.6 EL3502.4 R3501.1 USB1.9
USB3_USB31_RX_N: CPU1.CB5 EL3503.1 R3508.2
USB3_USB31_RX_P: CPU1.CB6 EL3503.2 R3502.2
USB3_USB31_TX_N: C3521.1 CPU1.CA4
USB3_USB31_TX_P: C3520.1 CPU1.CA3
USB4_USB20_CON_N: ED3502.3 EL3506.2 USB2.2
USB4_USB20_CON_P: ED3502.4 EL3506.3 USB2.3
USB4_USB20_N: CPU1.CG3 EL3506.1
USB4_USB20_P: CPU1.CG4 EL3506.4
USB4_USB30_RX_C_N: C7106.2 R7155.1
USB4_USB30_RX_C_P: C7105.2 R7156.1
USB4_USB30_RX_C_R_N: R7155.2 U7101.4
USB4_USB30_RX_C_R_P: R7156.2 U7101.5
USB4_USB30_RX_CON_N: ED3503.1 ED3503.10 EL3505.3 R3505.1 USB2.5
USB4_USB30_RX_CON_P: ED3503.2 ED3503.9 EL3505.4 R3504.1 USB2.6
USB4_USB30_RX_N: C7106.1 CPU1.BW6
USB4_USB30_RX_P: C7105.1 CPU1.BW5
USB4_USB30_TX_C_N: C7104.2 R7153.1
USB4_USB30_TX_C_P: C7103.2 R7154.1
USB4_USB30_TX_C_R_N: R7153.2 U7101.7
USB4_USB30_TX_C_R_P: R7154.2 U7101.8
USB4_USB30_TX_CMC_N: C3523.2 EL3504.1 R3506.2
USB4_USB30_TX_CMC_P: C3522.2 EL3504.2 R3503.2
USB4_USB30_TX_CON_N: ED3503.4 ED3503.7 EL3504.3 R3506.1 USB2.8
USB4_USB30_TX_CON_P: ED3503.5 ED3503.6 EL3504.4 R3503.1 USB2.9
USB4_USB30_TX_N: C7104.1 CPU1.BW2
USB4_USB30_TX_P: C7103.1 CPU1.BW1
USB4_USB31_RX_N: CPU1.BY7 EL3505.1 R3505.2
USB4_USB31_RX_P: CPU1.BY6 EL3505.2 R3504.2
USB4_USB31_TX_N: C3523.1 CPU1.BY4
USB4_USB31_TX_P: C3522.1 CPU1.BY3
USB30_PS_VCC: AFTP3507.1 C3524.1 C3525.1 C3526.1 C3527.1 EC3513.1 ED3502.5 FC8910.1 R3618.2 U3601.12 USB1.1
USB_ADT: PD4407.A PD4408.2 PD4409.A R7404.1 U7418.5 U7418.6 U7418.7 U7418.8 U7419.A1 U7419.B1 U7419.C1 U7419.D1
USB_EN#: AFTP6614.1 IOBD1.12 R2434.2 U2401.13 U3502.4
USB_OC0#: CPU1.CK6 R3512.1 R3607.2 RN1601.7(B)
USB_OC1#: AFTP6613.1 CPU1.CK5 IOBD1.11 RN1601.5(B)
USB_OC1#_R: R3512.2 U3502.3
USB_OC2#: CPU1.CK8 RN1601.8(B)
USB_OC3#: CPU1.CK9 RN1601.6(B)
USB_POWERSHARE_VBUS_EN: U2401.71 U3601.5
USB_PWR_SHR_EN_L#: R2492.2 R3601.1 U2401.118
USBC1_CC1_CONN: AFTP7303.1 C7208.1 ED7315.2 JUSB1.A5 U7201.6
USBC1_CC2_CONN: AFTP7304.1 C7209.1 ED7315.1 JUSB1.B5 U7201.4
USBCOMP: CPU1.CC5 R1603.1
V_SM_VREF_CNTA: C1222.1 CPU1.F36 R1206.2
V_SM_VREF_CNTB: C1323.1 CPU1.E36 R1305.2
VCI_IN1#: R2496.1 U2401.126
VCP_VBUS: D7401.A U7403.B1 U7403.B2 U7403.C1
VCREF0: C2409.1 R2424.1 R2448.1 U2401.25
VGA_CORE_DISCHG: Q8703.3 Q8705.3 R8702.2 R8706.2
VGA_CORE_PSI: PR8522.1 R7913.2 R7966.2
VGA_CORE_VID: PR8510.1 R7960.2 R7961.2
VGA_CORE_VID_R: GPU1.C6 R7959.1 R7960.1
VGA_CT_1: C8608.1 U8601.12
VGA_DB_DET#: AFTP5601.1 CPU1.CR24 R2059.2 R5601.2
VGA_DB_DET#_R: R5601.1 VGABD1.19
VGA_NVVDD: Q8703.5 Q8703.6 R8701.1
VGA_PWR_EN#: Q8701.5 Q8701.6 R8703.1
VGACORE_GND_SENSE_1: GPU1.F1 PR8520.2
VGACORE_VDD_SENSE_1: GPU1.F2 PR8517.2
VID_PLLVDD: GPU1.N6 R7943.2
VID_PLLVDD_L: C7902.1 C7934.1 C7935.1 GPU1.M6 L7902.2 R7943.1
VIDEO_CLK_XTAL_SS: GPU1.A10 R7901.1
VR_CAP: C2418.1 U2401.18
VR_EN: PU4601.40 R4002.2
VR_RDY: PR4609.2 PU4601.39 TP4601.1
VRALERT#: CPU1.CC36 TP1708.1
VRAM_ID1: CPU1.CE27 R2007.1 R2008.2
VRAM_ID2: CPU1.CN23 R2063.1 R2064.2
VREF_CPU: C2406.1 R2402.2 U2401.95
VREFD0_NC: VRAM1.A10
VREFD1_NC: VRAM1.U10
VREFD2_NC: VRAM2.A10
VREFD3_NC: VRAM2.U10
VREFD4_NC: VRAM3.A10
VREFD5_NC: VRAM3.U10
VREFD6_NC: VRAM4.A10
VREFD7_NC: VRAM4.U10
VREG3PD: C7216.1 C7217.1 D7201.A U7203.1
WHITE_LED_BAT: EC6404.1 Q6404.C R6406.1
WIFI_RF_EN: AFTP6110.1 CPU1.CG25 R6109.2
WIFI_RF_EN_R: R6109.1 R6114.2 WLAN1.56
WLAN_CLK_CPU_N: CPU1.BC1 WLAN1.49
WLAN_CLK_CPU_P: CPU1.BC2 WLAN1.47
WLAN_EN#: Q6102.D R6102.2 U6101.4
WLAN_PCIE_RX_N10: CPU1.BN6 WLAN1.43
WLAN_PCIE_RX_P10: CPU1.BN5 WLAN1.41
WLAN_PCIE_TX_CON_N: C6107.1 WLAN1.37
WLAN_PCIE_TX_CON_P: C6108.1 WLAN1.35
WLAN_PCIE_TX_N10: C6107.2 CPU1.BR4
WLAN_PCIE_TX_P10: C6108.2 CPU1.BR3
WWAN_BB_RST#: CPU1.CF17 WWAN1.16
WWAN_CLKREQ_CPU_N: CPU1.CF31 R1825.2 WWAN1.20
WWAN_DB_DET#: CPU1.CH36 R2119.2 R2403.2 R6201.1
WWAN_DB_DET#_R: R6201.2 WWAN1.17
WWAN_FULL_PWR_EN: CPU1.CM23 R2051.1
WWAN_FULL_PWR_EN_D8: CPU1.CJ22 R2067.1
WWAN_FULL_PWR_EN_R: R2051.2 R2067.2 WWAN1.8
WWAN_GPIO_PERST#: CPU1.CH22 WWAN1.15
WWAN_PCIE_CLK_N: CPU1.BE1 WWAN1.26
WWAN_PCIE_CLK_P: CPU1.BE2 WWAN1.27
WWAN_PCIE_RX_N: CPU1.BY8 WWAN1.29
WWAN_PCIE_RX_P: CPU1.BY9 WWAN1.30
WWAN_PCIE_TX_N: C6201.1 CPU1.CA2
WWAN_PCIE_TX_N_C: C6201.2 WWAN1.32
WWAN_PCIE_TX_P: C6202.1 CPU1.CA1
WWAN_PCIE_TX_P_C: C6202.2 WWAN1.33
WWAN_PCIE_WAKE_N: TP6201.1 WWAN1.21
WWAN_USB20_N: CPU1.CB8 R6203.1
WWAN_USB20_N_R: R6203.2 WWAN1.23
WWAN_USB20_P: CPU1.CB9 R6202.1
WWAN_USB20_P_R: R6202.2 WWAN1.24
XCLK_BIASREF: CPU1.CJ1 R1803.1
XDP_CLK_CPU_N: CPU1.AU1 TP1808.1
XDP_CLK_CPU_P: CPU1.AU2 TP1807.1
XDP_DBRESET#: CPU1.CN10 R1701.2
XDP_PRDY#: CPU1.W1 TP9107.1
XDP_PREQ#: CPU1.W2 TP9106.1
XDP_TCK_JTAGX: CPU1.P6 R315.1
XDP_TCLK: CPU1.T6 R317.1
XDP_TDI: CPU1.U6 R311.1
XDP_TDO_CPU: CPU1.Y5 R310.1
XDP_TMS: CPU1.T5 R309.1
XDP_TRST#: CPU1.AB6 CPU1.Y6 R316.1
XTL_24M_X1_CPU: CPU1.CK3 R1839.1
XTL_24M_X1_R: C1807.2 R1839.2 R1841.1 X1801.1
XTL_24M_X2_CPU: CPU1.CK2 R1840.1
XTL_24M_X2_R: C1808.2 R1840.2 R1841.2 X1801.3
XTL_32K_X1_CPU: C1804.1 CPU1.BN31 R1815.1 X1802.1
XTL_32K_X2_CPU: C1803.1 CPU1.BN32 R1815.2 X1802.2
XVDD_R1: GPU1.V5 R8001.2
XVDD_R2: GPU1.V6 R8002.2
N92950396: C2517.1 D2502.A Q2510.G R2567.2

Pads without a net: CPU1 A34 A35 AA24 AA26 AB25 AC6 AC7 AC24 AC25 AC26 AD24 AD26 AG6 AG7 AH26 AJ1 AJ2 AJ3 AJ4 AJ27 AL1 AL2 AL3 AL4 AM3 AM4 AM7 AN1 AN2 AN3 AN4 AR3 AT3 AU3 AY9 B35 BB9 BB24 BC24 BC28 BH3 BH4 BJ34 BJ36 BK34 BK35 BK36 BL34 BL36 BL37 BP8 BP9 BP28 BP29 BP34 BP35 BR18 BT8 BT9 BT31 BU29 BV24 BV25 BV30 BW34 BW35 BW36 BW37 BY30 BY31 C34 CA32 CA34 CA35 CA36 CA37 CF12 CF22 CF27 CF29 CG1 CG2 CG14 CG23 CH7 CH8 CH9 CH20 CH25 CH27 CH28 CH30 CH32 CJ27 CJ29 CJ30 CJ31 CK17 CK22 CK23 CM16 CM18 CM19 CM20 CM27 CM28 CM35 CN8 CN16 CN18 CN19 CN22 CN26 CN28 CN35 CN36 CP3 CP4 CP6 CP16 CP18 CP26 CP28 CR3 CR4 CR16 CR18 CR20 CR28 CR35 D34 D35 D37 F34 F37 G1 G2 G3 G4 H3 H4 J1 J2 J3 K12 K14 K15 K17 K18 K20 L1 L2 L3 L4 L5 L25 M3 M4 M24 M26 N1 N2 N3 N4 N5 P24 P26 R1 R2 R4 R24 R25 R26 T3 T4 T25 U34 U35 V24 V25 V28 V29 W3 W25 Y3 Y24 Y25; DBG1 1 12; DCIN1 5; DM1 87 88 91 92 95 97 100 101 104 105 162 165; DM2 87 88 91 92 95 97 100 101 104 105 162 165; ED2403 1; ED5703 4 7; ED9202 3 4; GPU1 A16 A22 AA1 AA2 AA3 AA4 AA5 AA6 AB1 AB2 AB3 AB4 AB5 AB6 AB13 AB15 AB16 AB18 AB19 AB21 AB27 AC3 AC4 AC13 AC14 AC15 AC16 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD14 AD17 AD20 AD23 AE1 AE3 AE4 AE10 AE12 AE13 AE15 AE16 AE18 AE19 AE21 AE23 AE24 AF2 AF3 AF4 AF10 AF12 AF13 AF15 AF16 AF18 AF19 AF21 AF24 AG3 AG12 AG13 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B3 B6 B19 C2 C3 C7 C14 D4 D5 D10 D11 D12 D23 E6 E10 E12 F4 F5 F7 F10 F12 F19 P25 T27 V7 W5 W6 W7 W22 Y3 Y4 Y6; HDA27 10; HDD1 5 7; HDMI1 13 14; IOBD1 16; KB1 2 3; KBBL1 3; LCD1 38; ODD1 8 11; PU4501 15; PU4701 4 6 27 30 31 35; PU4801 4 6 27 30 31 35; PU4802 4 6 27 30 31 35; PU5102 26; PU5301 5; PU8602 12; PU8603 5; RN1704 5; RN4302 1 8; SSD1 6 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67 68; U2502 3; U3101 25; U3601 9; U5501 3; U5802 4 14 22 23 31 32 34 35 58; U6101 3; U7102 6 7 19 20; U7202 4; U7203 2 5; U9103 3 5 9 10 11 12 14 15 25 26 27 28 31 32; VGABD1 2 5; VRAM1 A5 A11 A13 B11 B13 D13 E11 E13 F11 F13 M2 M4 N2 N4 P2 R2 T2 T4 U2 U4 U5; VRAM2 A5 A11 A13 B11 B13 D13 E11 E13 F11 F13 M2 M4 N2 N4 P2 R2 T2 T4 U2 U4 U5; VRAM3 A5 A11 A13 B11 B13 D13 E11 E13 F11 F13 M2 M4 N2 N4 P2 R2 T2 T4 U2 U4 U5; VRAM4 A5 A11 A13 B11 B13 D13 E11 E13 F11 F13 M2 M4 N2 N4 P2 R2 T2 T4 U2 U4 U5; WLAN1 6 8 12 16 20 38 40 42 44 46 48 58 60 62 66 68 70; WWAN1 6 9 10 11; X1801 2

## Via types
v1: diameter 0.356, hole 0.178, TOP to BOTTOM, 1156 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 4962 vias
v3: diameter 0.559, hole 0.305, TOP to BOTTOM, 24 vias
v4: diameter 0.711, hole 0.406, TOP to BOTTOM, 697 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V_CPU_CORE: length 45.2
  TOP w0.305: v2(88.09,149.76) PR4631.2
  L5 w0.254: v4(80.09,126.84) 80.32,127.06 80.32,127.09 81.18,127.95 81.18,133.76 85.19,137.77 85.19,142.47 84.53,143.13 84.53,145.01 84.08,145.47 83.29,145.47 82.91,145.85 82.91,147.07 83.42,147.58 85.09,147.58 87.27,149.76 v2(88.09,149.76)
  BOTTOM w0.254: CPU1.AR7 v2(89.85,102.72) ; CPU1.AV7 v2(91.7,102.72) ; CPU1.AR6 v2(89.85,103.36) 89.74,103.36 89.39,103.7 CPU1.AR5 ; CPU1.AV2 91.24,106.66 v2(91.29,106.71) ; CPU1.AW5 v2(92.63,104.01) ; CPU1.BA8 v2(93.55,102.09) ; CPU1.AR8 v2(89.85,102.09) ; CPU1.AV5 90.81,103.36 v2(90.78,103.36) CPU1.AU6 ; CPU1.BB2 v2(93.68,106.69) ; CPU1.BA7 v2(93.55,102.72) ; CPU1.AP2 v2(88.8,106.69) ; CPU1.AU8 v2(90.78,102.09) ; CPU1.AU7 v2(90.78,102.72) ; CPU1.BF2 v2(96.12,106.69) ; CPU1.BA5 93.09,103.7 92.74,103.36 v2(92.63,103.36) CPU1.AW6 ; CPU1.AW7 v2(92.63,102.72) ; CPU1.AU5 v2(90.78,104.01) ; CPU1.AW8 v2(92.63,102.09)
  BOTTOM w0.305: v2(94.47,103.36) CPU1.BD5 ; v2(94.47,103.36) CPU1.BC5 ; v2(94.47,103.36) CPU1.BC6 ; CPU1.BC7 v2(94.47,102.72)
  vias: v1(76.04,124.1) v1(82.32,116.16) v1(83.82,125.4) v1(89.31,90.88) v1(90.25,101.22) v1(93.2,101.35) v2(88.05,89.81) v2(88.96,89.81) v2(89.87,89.82) v2(90.78,89.81) v2(91.7,89.81) v2(92.61,89.81) v2(93.52,89.81) v2(94.43,89.81) v2(95.34,89.81) v2(96.25,89.81) v4(73.59,126.72) v4(73.59,125.88) v4(73.59,125.04) v4(73.57,124.2) v4(73.89,123.37) v4(74.48,126.71) v4(74.48,125.87) v4(74.48,125.03) v4(74.45,124.2) v4(74.73,123.37) v4(75.23,127.07) v4(75.57,123.35) v4(76.46,123.35) v4(77.35,123.35) v4(78.24,123.35) v4(78.36,127.01) v4(79.07,123.37) v4(79.25,126.84) v4(79.25,126) v4(79.25,125.04) v4(79.25,124.21) v4(79.91,123.37) v4(80.09,126) v4(80.09,125.04) v4(80.09,124.21) v4(80.75,123.37) v4(80.93,126.84) v4(80.93,126) v4(80.93,125.04) v4(80.93,124.21) v4(81.59,123.37) v4(81.77,126.84) v4(81.77,126) v4(81.77,125.04) v4(81.79,124.21) v4(82.43,123.35) v4(82.59,127.01) v4(83.32,123.35) v4(83.44,127.01) v4(84.2,123.35) v4(85.05,123.35) v4(85.88,96.62) v4(85.91,95.78) v4(85.91,94.95) v4(85.91,94.06) v4(85.91,93.12) v4(85.98,127.05) v4(86.82,127.05) v4(87.53,92.08) v4(88.4,100.26) v4(89.41,100.26) v4(89.46,92) v4(90.4,92) v4(91.19,100.26) v4(92.21,100.26) v4(92.15,92) v4(92.54,98.65) v4(92.54,97.77) v4(92.54,96.9) v4(92.54,95.94) v4(92.54,95.07) v4(92.54,94.24) v4(92.54,93.22) v4(93.14,92.03) v4(93.98,100.26) v4(95,100.26)
1V_GT_CORE: length 3.7
  BOTTOM w0.127: CPU1.AF2 v2(83.92,107.24) ; CPU1.AB2 v2(81.45,107.14)
  BOTTOM w0.254: CPU1.AK2 86.36,106.48 v2(86.19,106.66) ; CPU1.V2 v2(79.04,107.19)
  vias: v1(81.71,100.92) v2(80.61,102.05) v2(81.55,102.07) v2(82.46,102.05) v2(83.39,102.06) v4(80.13,100.26) v4(81.2,100.26) v4(82.83,100.26) v4(83.97,100.26) v4(85.6,100.26)
1V_VCCGT: length 24.8
  L5 w0.305: v4(65.15,127.33) 65.15,128.65 63.22,130.58 63.22,133.78 62.87,134.14 62.87,134.75 63.43,135.31 63.6,135.31 64.32,136.02 64.32,136.78 71.02,143.49 v2(71.02,144.22)
  BOTTOM w0.127: v2(74.2,107.11) 74.15,107.07 CPU1.K2
  BOTTOM w0.152: CPU1.P2 76.6,106.22 76.59,106.23 76.59,107.26 v2(76.51,107.34)
  BOTTOM w0.305: PR4663.1 71.03,144.23 v2(71.02,144.22)
  BOTTOM w0.508: R807.1 70.54,110.14 v2(70.36,110.32)
  vias: v1(76.53,101.58) v2(68.51,99.04) v2(68.53,97.21) v2(68.59,98.14) v2(68.59,96.26) v2(69.24,98.14) v2(69.24,96.26) v2(69.89,100.03) v2(69.89,98.14) v2(69.89,97.2) v2(69.89,96.26) v2(70.54,100.03) v2(70.54,99.08) v2(70.54,98.14) v2(70.54,97.2) v2(70.54,96.26) v2(71.19,100.03) v2(71.19,98.14) v2(71.19,96.26) v2(71.78,104.34) v2(71.84,100.03) v2(71.84,99.08) v2(71.84,98.14) v2(71.84,97.2) v2(71.84,96.26) v2(72.27,103.43) v2(72.27,102.8) v2(72.49,100.03) v2(72.49,99.08) v2(72.49,98.14) v2(72.49,97.2) v2(72.49,96.26) v2(72.52,95.31) v2(73.14,100.03) v2(73.14,98.14) v2(73.14,96.26) v2(73.18,104.08) v2(73.17,103.44) v2(73.16,102.8) v2(73.79,100.03) v2(74.17,102.8) v2(75.01,102.8) v2(75.11,102.13) v2(75.95,102.8) v2(75.97,102.13) v4(64.27,126.67) v4(64.28,125.83) v4(65.06,123.98) v4(65.15,126.49) v4(65.15,125.66) v4(65.17,124.81) v4(65.61,123.34) v4(66.45,123.32) v4(67.29,123.32) v4(68.13,123.29) v4(68.96,123.29) v4(69.8,126.72) v4(69.8,125.86) v4(69.8,124.94) v4(69.8,124.08) v4(69.8,123.24) v4(70.69,126.72) v4(70.69,125.86) v4(70.69,124.94) v4(70.69,124.08) v4(70.69,123.24) v4(75.76,94.49) v4(75.76,93.65) v4(76.6,94.49) v4(76.6,93.65) v4(77.44,94.49) v4(77.44,93.65) v4(78.28,94.49) v4(78.28,93.65) v4(79.11,94.49) v4(79.11,93.65) v4(79.95,94.49) v4(79.95,93.65) v4(80.79,94.49) v4(80.79,93.65) v4(81.63,94.49) v4(81.63,93.65)
1V_VCCIO: length 1.1
  BOTTOM w0.305: CPU1.BP16 101.35,96.58 v2(101.35,96.48) 101.35,96.39 CPU1.BP18
  vias: v1(108.21,129.29) v2(85.86,91.9) v2(86.22,89.86) v2(87.13,89.85) v2(97.16,89.81) v2(97.29,92.05) v2(97.97,92.08) v2(98.08,89.81) v4(107.57,129.47) v4(107.57,128.6) v4(108.08,130.23) v4(108.46,128.58)
1V_VCCSA:
  vias: v1(91.19,124.51) v1(94.8,124.44) v2(97.24,102.07) v2(98.17,102.07) v2(98.68,96.83) v2(98.67,91.89) v2(98.96,89.82) v2(99.09,102.07) v2(99.34,98.99) v2(100.02,92.18) v4(90.3,128.32) v4(90.3,127.43) v4(90.3,126.54) v4(90.3,125.66) v4(95.18,128.32) v4(95.18,127.48) v4(95.18,126.65) v4(95.18,125.81) v4(96.03,128.35) v4(96.03,127.52) v4(96.04,126.65) v4(96.02,125.81) v4(96.65,100.26) v4(97.49,100.26) v4(98.71,99.39) v4(98.71,98.55) v4(98.71,97.59) v4(99.42,100.31) v4(99.44,98.1) v4(99.44,97.08)
1V_VCCST_CPU: length 111.2
  TOP w0.508: 96.8,115.73 99.34,113.19 99.34,112.67 99.72,112.29 99.72,111.58 100.13,111.18 100.13,107.93 100.82,107.24 v2(101,107.24) 100.51,106.75 100.51,104.56 ; v2(121.1,116.3) 121.21,116.19 121.21,115.8 120.7,115.29 118.87,115.29 R4036.2 ; v2(96.73,125.11) 96.75,125.09 96.75,124.3 96.52,124.07 v2(96.52,119.18) C807.1 96.57,117.98 C805.2
  L5 w0.508: 107.83,131.01 107.5,131.34 107.5,134.53 103.73,138.3 102.32,138.3 101.73,138.89 101.73,139.6 99.95,141.38 99.95,141.79 97.51,144.22 97.51,146.29 97.67,146.44 97.67,147.83 97.18,148.31 v2(97.18,151.11) ; 107.83,131.01 v2(108.72,131.01) ; 107.83,131.01 106.71,129.9 106.71,126.85 105.97,126.11 99.79,126.11 98.67,124.99 96.9,124.99 96.79,125.11 v2(96.73,125.11)
  L6 w0.508: v2(116.82,126.44) 116.82,127.18 116.13,127.86 112.61,127.86 112.41,128.07 112.4,128.07 109.45,131.01 v2(108.72,131.01) ; v2(84.59,152.4) 84.59,151.89 85.42,151.06 90.77,151.06 90.9,151.18 91.76,151.18 91.98,151.4 91.99,151.4 92.01,151.42 96.76,151.42 96.89,151.29 97,151.29 v2(97.18,151.11)
  BOTTOM w0.152: v2(101,107.24) CPU1.BP2
  BOTTOM w0.305: v1(93.79,118.94) 91.9,117.04 C801.1 91.72,116.05 R308.1
  BOTTOM w0.508: v2(116.82,126.44) 118.27,124.99 118.27,122.2 121.24,119.23 121.24,116.43 121.11,116.31 121.11,116.3 v2(121.1,116.3) ; v2(96.52,119.18) 94.03,119.18 v1(93.79,118.94)
  vias: v2(100.99,100.77) v2(102.05,100.76)
1V_VCCST_CPU_R: length 0.9
  TOP w0.305: C4012.1 117.37,115.38 R4036.1
  vias: v1(116.26,117.22)
1V_VCCSTG: length 89.4
  TOP w0.254: 78.58,105.4 78.58,106.16 78.31,106.43 78.31,109.77 75.92,112.16 v2(75.9,112.16) ; 78.58,105.4 78.65,105.48 79.79,105.48 R310.2 ; 78.58,105.4 78.56,105.39 R311.2 R309.2 R315.2 ; R4038.2 110.07,126.79 109.63,127.23 v2(109.45,127.23)
  L3 w0.254: v2(96.16,107.34) 94.77,108.73 94.77,111.41 93.14,113.03 93.14,113.72 88.85,118.02 88.85,123.17 88.27,123.76 v2(88.27,123.88)
  L5 w0.254: v2(109.45,127.23) 107.88,127.23 106.25,125.61 100,125.61 98.66,124.26 88.67,124.26 88.29,123.88 v2(88.27,123.88) ; v2(88.22,112.19) 88.22,111.1 90.38,108.94 90.38,108.36 92.57,106.17 94.52,106.17 95.68,107.34 v2(96.16,107.34)
  L6 w0.254: v2(81.61,112.32) 81.74,112.19 v2(88.22,112.19)
  BOTTOM w0.254: C802.1 75.87,114.53 75.19,113.84 ; C802.1 78.11,114.43 R313.2 R301.1 ; C802.1 78.21,115.24 v1(78.39,115.42) 78.44,115.37 79.61,115.37 FC8981.1 81.59,113.39 81.59,112.35 v2(81.61,112.32) ; R314.2 R312.2 75.11,113.77 75.19,113.84 ; 75.19,113.84 75.19,112.88 v2(75.9,112.16) ; v2(96.16,107.34) 96.3,107.34
1V_VGA_CORE: length 49.3
  TOP w0.305: PR8504.1 138.41,79.62 v2(138.79,80)
  TOP w0.508: R8706.1 111.13,142.83 v1(111.74,142.24) 112.1,141.86 112.55,141.4 115.09,141.4 115.6,140.9 115.6,138.56 116.28,137.87 v2(116.39,137.87)
  L5 w0.305: v2(138.79,80) 138.55,80 137.32,81.23 137.32,87.4 139.59,89.68 139.59,96.95 v4(140.8,98.15)
  L5 w0.508: v4(121.42,127.99) 122.05,128.62 122.05,129.85 121.06,130.84 v2(118.42,130.84)
  L6 w0.508: v2(118.42,130.84) 116.73,132.53 116.73,137.53 v2(116.39,137.87)
  vias: v1(132.44,112.29) v1(139.09,99.32) v1(145.8,105.92) v1(146.94,100.97) v1(148.69,106.55) v2(123.68,127.33) v2(124.24,127.9) v2(124.77,128.44) v2(124.83,127.29) v2(124.86,126.13) v2(125.36,129.01) v2(125.4,127.86) v2(125.43,126.7) v2(125.43,125.59) v2(125.99,127.26) v2(125.99,126.13) v2(126.05,123.81) v2(126.56,127.83) v2(126.56,126.7) v2(126.59,125.54) v2(126.62,124.38) v2(126.62,123.25) v2(127.13,127.27) v2(127.15,126.1) v2(127.18,124.95) v2(127.18,123.81) v2(127.72,127.86) v2(127.75,125.51) v2(127.75,124.38) v2(128.05,131.38) v2(128.34,123.79) v2(128.73,131.93) v2(129.07,120.91) v2(129.31,129.82) v2(130.08,130.63) v2(130.08,122.03) v2(130.16,133.36) v2(130.66,122.6) v2(131.25,122.01) v2(131.5,132.01) v2(131.83,122.6) v2(132.84,130.68) v2(132.88,133.45) v2(132.97,136.27) v2(134.34,134.87) v2(134.32,132.02) v2(134.32,129.14) v2(135.72,130.61) v2(135.79,133.48) v2(137.14,131.95) v4(122.03,127.34) v4(122.61,126.7) v4(123.2,126.1) v4(124.35,124.88) v4(124.94,124.29) v4(125.45,123.32) v4(126.07,122.73) v4(126.73,121.89) v4(127.59,121.26) v4(128.26,120.4) v4(141.86,98.15) v4(142.98,98.17) v4(144.05,98.17) v4(144.55,101.4) v4(144.57,100.32) v4(144.57,99.18) v4(145.21,98.17) v4(145.47,102.64) v4(145.47,101.79) v4(146.31,102.67) v4(146.34,101.79) v4(146.28,98.18) v4(147.2,102.67) v4(147.2,101.78) v4(147.4,98.2) v4(148.06,102.64) v4(148.06,101.8) v4(148.43,103.47) v4(148.45,105.35) v4(148.46,104.35) v4(148.55,98.19) v4(148.97,102.64) v4(148.97,101.8) v4(149.32,105.4) v4(149.35,104.36) v4(149.3,103.52) v4(149.74,98.22) v4(149.78,100.89) v4(149.78,100) v4(149.78,99.11) v4(150.23,105.39) v4(150.23,104.48) v4(150.23,103.52)
1V_VGA_S0: length 16.6
  L3 w0.508: v2(105.69,144.58) 105.69,144.95 107.22,146.48 112.58,146.48 114.18,144.88 118.14,144.88 v4(119.31,143.71)
  BOTTOM w0.508: v2(105.69,144.58) 105.69,144.74 106.07,145.12 R8702.1
  vias: v1(135.36,151.18) v2(134.15,144.83) v2(134.18,143.66) v2(134.71,146.94) v2(135.04,147.59) v2(135.46,148.06) v4(120.22,143.71) v4(121.06,143.74)
1V_VGA_S0_EN: length 43.5
  TOP w0.089: v2(96.99,147.37) 96.74,147.37 96.32,147.8 95.97,147.8 95.47,147.3 U8801.4 ; v1(107.45,148.76) v2(107.7,148.26)
  L5 w0.089: v2(96.99,147.37) 96.75,147.62 96.75,147.62 96.68,147.69 96.68,154.84 97.21,155.37 103.79,155.37 v2(104.45,154.71) ; v2(108.66,154.76) 108.13,154.23 108.13,153.04 108.46,152.71 108.46,149.34 107.83,148.71 107.81,148.71 107.7,148.59 v2(107.7,148.26) 107.7,147.4 108.79,146.31 108.79,143.8 110.75,141.84 112.64,141.84 v2(112.92,142.11)
  L6 w0.089: v2(104.45,154.71) 104.97,155.24 108.19,155.24 v2(108.66,154.76)
  BOTTOM w0.089: PU8603.7 112.53,142.5 v2(112.92,142.11) ; v2(107.7,148.26) 107.7,147.25 107.47,147.02 Q8703.2
1V_VGA_S0_PG: length 10
  TOP w0.089: v2(109.2,141.48) 109.1,141.38 R8806.2 ; v2(107.45,145.81) 107.45,147.16 v1(107.41,147.19) 107.21,147.39 U8803.1
  L5 w0.089: v2(109.2,141.48) 109.2,142.83 108.21,143.82 108.21,145.05 v2(107.45,145.81)
  BOTTOM w0.089: PU8603.2 110.04,142.5 109.2,141.66 v2(109.2,141.48)
3V5V_CT1: length 0.9
  TOP w0.127: C4001.1 45.04,132.08 U4001.12
3V5V_CT2: length 3.6
  TOP w0.127: C4002.1 61.88,38.43 v1(61.84,38.39) v2(61.24,37.8)
  BOTTOM w0.127: v2(61.24,37.8) 60.89,37.45 U4004.12
3V_5V_DSW_OK: length 181.6
  TOP w0.089: v2(172.94,63.4) 172.91,63.43 172.91,67.37 173.9,68.36 173.9,70.59 172.7,71.79 172.7,73.34 171.67,74.37 169.37,76.67 169.37,78.23 v2(169.68,78.54) ; PR5308.2 69.8,39.98 v1(69.8,39.12) 69.47,39.12 v2(68.96,39.63)
  L5 w0.089: v2(172.94,63.4) 172.47,62.93 172.47,62.36 172.59,62.23 172.59,62.13 172.62,62.11 172.62,59.51 173.15,58.98 173.15,55.63 174.5,54.28 174.5,52.04 175.88,50.67 175.88,48.75 175.14,48.01 174.02,48.01 172.97,46.96 172.97,43.78 170.61,41.42 169.4,41.42 169.19,41.21 167.18,39.2 158.85,39.2 158.42,39.63 158.42,40.11 157.66,40.87 157.56,40.97 151.67,40.97 151.03,40.34 142.07,40.34 140.49,41.91 132.46,41.91 132.11,42.27 129.53,42.27 127.23,44.57 111.37,44.57 110.12,43.32 106.04,43.32 105.16,42.44 105.16,42 104.69,41.53 104.47,41.53 103.37,40.43 101.49,40.43 101.27,40.2 93.66,40.2 93.08,39.63 93.07,39.63 92.94,39.49 91.3,39.49 91.17,39.63 v2(68.96,39.63) ; v2(169.68,78.54) 168.53,78.54 167.28,79.79 167.28,84.7 164.62,87.36 164.62,89.23 161.52,92.33 v2(161.52,93.35)
  BOTTOM w0.089: v2(161.52,93.35) 161.52,93.65 161.21,93.96 160.49,93.96 159.46,92.93 159.24,92.93 159.09,92.79 158.58,92.79 158.31,93.06 D2503.3 156.83,93.06 156.62,93.27 ; 156.62,93.27 156.21,92.86 R2514.2 ; 156.62,93.27 156.62,93.98 157.32,94.68 U2502.4
3V_5V_EN: length 407
  TOP w0.089: PR4516.1 64.54,133.88 64.39,134.04 63.24,134.04 63.04,134.24 63.04,136.99 62.26,137.77 62.26,139.42 v2(62.13,139.55) ; v2(165.13,56.49) 163.32,56.49 159.86,59.95 156.78,59.95 154.54,62.19 154.54,65.83 148.45,71.91 R4006.1 147.03,71.73 C4009.1 146.23,71.98 147.07,72.82 R4014.1 147.81,73.47 D4001.A ; v2(35.79,35.51) 35.18,34.9 35.18,32.26 v1(34.94,32.02) v2(30.18,27.26)
  L5 w0.089: v2(102.82,33.8) 102.47,33.45 98.17,33.45 97.45,34.17 97.4,34.17 82.72,34.17 82.18,33.63 81.41,33.63 80.81,34.23 54.69,34.23 52.85,32.4 35.86,32.4 30.71,27.26 v2(30.18,27.26) 30.38,27.05 30.38,26.14 29.77,25.52 22.7,25.52 19.34,28.88 18.88,28.88 15.86,31.9 15.86,35.17 16.35,35.66 16.35,49.27 15.73,49.89 15.73,56.84 21.87,62.97 21.87,63.56 22.24,63.94 22.82,63.94 23.47,64.59 23.47,66.26 25.07,67.86 v2(25.07,68.92) 25.07,69.8 27.47,72.2 27.47,74.32 28.5,75.36 29.18,75.36 29.82,76 36.85,76 37,76 38.86,77.86 38.86,91.38 36.39,93.85 30.72,93.85 30.23,94.34 30.23,99.35 26.57,103 26.57,112.87 27.56,113.86 27.56,115.85 26.87,116.54 26.87,120.33 26.51,120.69 26.51,124.9 30.56,128.94 44.46,128.94 45.18,129.66 45.81,129.66 45.98,129.5 50.87,129.5 55.96,134.59 55.96,138 57.28,139.32 60.84,139.32 61.19,139.68 62,139.68 v2(62.13,139.55)
  L6 w0.089: v2(101.86,42.72) 103.05,43.92 103.05,44.67 104.37,45.99 104.73,45.99 105.11,45.61 105.11,45.46 105.36,45.22 109.57,45.22 110.61,46.25 127.05,46.25 129.4,43.91 169.45,43.91 169.79,44.25 169.81,44.3 169.81,51.81 v2(165.13,56.49)
  BOTTOM w0.089: v2(35.79,35.51) 35.79,37.82 35.61,38 35.61,39.12 PR4504.1 ; R4009.1 24.62,69.37 v2(25.07,68.92) ; v2(102.82,33.8) 102.67,33.95 102.67,35.9 102.3,36.27 102.3,37.97 100.34,39.93 100.34,41.63 101.43,42.72 v2(101.86,42.72)
3V_5V_POK: length 441.9
  TOP w0.089: Q1701.2 157.74,71.96 157.34,72.36 157.31,72.36 v2(156.98,72.7) ; v2(166.5,59.03) 164.78,60.75 164.78,62.43 163.78,63.43 163.78,66.88 164.95,68.05 165.03,68.05 167.31,70.33 167.31,72.97 167.74,73.39 167.74,73.94 167.49,74.19 167.45,74.19 v2(167.31,74.32) ; v2(81.87,34.32) 80.11,34.32 R4033.1 ; v2(155.81,90.68) 156.31,90.68 156.85,90.15 157.18,90.15 158.02,89.31 158.02,83.11 158.58,82.55 158.58,82.14 158.48,82.05 158.48,81.34 v2(158.12,80.98) ; v2(29.09,26.6) 29.62,27.13 29.62,27.44 32.77,30.59 32.77,33.34 36.74,37.31 36.74,37.68 37.29,38.22 39.05,38.22 v1(39.27,38) v2(39.75,37.52)
  L5 w0.089: v2(61.57,139.24) 61.47,139.14 57.35,139.14 56.21,138 56.21,134.59 50.94,129.32 45.89,129.32 45.72,129.48 45.37,129.48 44.64,128.75 30.62,128.75 26.69,124.82 26.69,120.97 27.16,120.49 27.16,116.76 27.76,116.16 27.76,113.81 26.75,112.8 26.75,103.08 28.68,101.14 31.28,101.14 36.83,95.59 36.83,94.16 39.04,91.96 39.04,77.78 37.06,75.81 29.92,75.81 29.23,75.11 29.23,73.01 26.73,70.51 26.6,70.51 25.96,69.87 25.96,68.5 23.64,66.19 23.64,64.24 22.78,63.37 22.78,63.02 22.53,62.77 21.92,62.77 15.91,56.76 15.91,49.96 16.53,49.34 16.53,35.99 17.01,35.51 17.01,32.26 20.42,28.86 20.42,28.6 22.96,26.06 26.36,26.06 26.68,26.38 28.88,26.38 v2(29.09,26.6) 29.57,27.08 29.57,27.51 29.93,27.86 30.07,27.86 30.81,27.86 35.71,32.76 35.81,32.76 35.81,32.76 52.71,32.76 54.54,34.59 81.59,34.59 v2(81.87,34.32) 82.08,34.53 96.58,34.53 97.54,34.53 97.55,34.53 97.61,34.53 98.33,33.8 101.65,33.8 103.18,35.34 106.15,35.34 106.36,35.55 106.36,35.55 107.6,36.79 v2(107.6,36.96)
  L6 w0.089: v2(167.31,74.32) 167.92,74.93 167.92,75.34 163.8,79.46 163.32,79.46 162.33,80.44 158.85,80.44 158.32,79.91 157.94,79.91 157.69,80.16 157.69,80.55 v2(158.12,80.98) ; v2(104.55,45.57) 105.08,45.04 109.64,45.04 110.68,46.08 126.95,46.08 129.3,43.73 169.53,43.73 169.99,44.2 169.99,55.44 168.33,57.1 168.33,57.6 166.9,59.03 v2(166.5,59.03)
  BOTTOM w0.089: 60.1,135.05 59.89,134.84 PU4501.9 ; 60.1,135.05 60.25,135.21 61.29,135.21 PR4505.2 61.45,137.1 ED1703.2 62.17,138.22 61.57,138.81 v2(61.57,139.24) ; 60.1,135.05 60.34,134.82 PU4501.10 ; v2(107.6,36.96) 107.27,36.96 105.84,38.38 105.84,41.02 105.27,41.6 105.27,44.52 104.55,45.24 v2(104.55,45.57) ; v2(155.81,90.68) 156.77,91.64 158.19,91.64 D2503.1 ; v2(156.98,72.7) 157.4,72.27 161.34,72.27 163.98,74.91 166.73,74.91 v2(167.31,74.32)
