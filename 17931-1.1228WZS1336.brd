# Allegro board 17931-1.1228WZS1336.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
3D3V_CAMERA: length 5.2
  BOTTOM w0.508: F5504.1 157.38,100.13 R5501.2 158.04,101.27 159.18,102.41 v1(159.18,102.97) 159.24,103.02 159.24,104.17
3D3V_CAMERA_CT1: length 1.9
  BOTTOM w0.089: U5503.12 159.13,104.99 C5539.1 159.87,104.24 v1(159.87,104.01)
3D3V_CAMERA_S0: length 127.5
  TOP w0.508: v2(212.43,43.56) 212.89,43.1 212.89,43.07 214.63,41.33 214.63,37.22 216.05,35.81 v2(216.05,34.77)
  L3 w0.508: v2(167.03,94.08) 167.67,93.45 167.67,81.46 169.29,79.84 170.3,79.84 170.3,79.84 170.66,79.84 176.16,74.33 176.16,74.05 177.59,72.62 178.06,72.62 181.06,70.59 181.48,70.18 v2(181.48,70.16) ; v2(216.05,34.77) 219.91,34.77 222.67,37.53 222.67,61.58 223.61,62.52 223.61,64.64 222.67,65.58 222.67,66.66 v2(222.81,66.8)
  L6 w0.508: v2(222.81,66.8) 222.02,67.59 211.46,67.59 210.19,66.32 199.93,66.32 197.89,64.29 188.85,64.29
  BOTTOM w0.305: LCD1.23 219.51,46.05 219.59,46.13 v2(219.71,46.13)
  BOTTOM w0.508: F5504.2 158.65,98.37 162.28,94.74 166.37,94.74 v2(167.03,94.08)
  vias: v2(216.23,43.99)
3D3V_GSEN2: length 6.4
  TOP w0.254: R7006.2 133.99,94.18 v1(134.42,94.62) 134.52,94.62 134.83,94.3 v2(135.49,94.3) 135.49,94.84 R7004.2
  BOTTOM w0.254: U7001.10 135.21,93.45 C7004.1 136.05,93.6 C7003.1 135.6,94.41 v2(135.49,94.3) U7001.9
3D3V_LAN_CT2: length 1
  TOP w0.127: U4001.10 44.85,132.88 C4017.1
3D3V_LAN_S5: length 56.6
  TOP w0.203: U3101.11 45.49,80.85 45.29,80.65 45.24,80.65 45.24,80.63 v2(45.26,80.63)
  L5 w0.305: v2(49.18,81.61) 49.18,82.09 48.69,82.58 48.69,84.22 v2(49.59,85.12)
  L5 w0.508: v2(45.26,80.63) 45.39,80.76 45.39,85.04 44.5,85.93 v2(44.23,85.93)
  BOTTOM w0.203: v2(49.59,85.12) 49.16,84.68 C3117.1
  BOTTOM w0.254: C3110.1 44.96,85.22 C3121.1 44.28,85.89 v2(44.23,85.93) ; LED2.A 11.45,65.15 15.39,69.09 18.91,69.09 20.2,70.39 22.92,70.39 23.28,70.74 26,70.74 26.07,70.82 26.67,70.82 27.68,71.83 28.17,71.83 31.26,74.92 31.26,75.33 31.57,75.64 33.42,75.64 33.9,76.12 37.4,76.12 38.02,76.74 40.18,76.74 40.81,77.37 42.8,77.37 v1(43.73,78.3) 45.6,80.16
3D3V_LAN_S5_R: length 76.7
  TOP w0.508: R4047.1 42.32,89.54 v1(41.96,89.9) 40.36,91.49 27.44,91.49 27.08,91.85 v2(27.08,92.18)
  L5 w0.508: v2(27.08,92.18) 27.08,95.89 26.19,96.78 26.19,97.04 21.77,101.46 21.77,103.38 21.34,103.81 21.34,108.48 20.3,109.53 v2(19.69,109.53)
  L6 w0.508: v2(42.98,133.12) 42.52,132.67 42.52,126.49 39.83,123.8 39.83,122.41 38.68,121.26 38.04,121.26 37.96,121.34 36.71,121.34 36.02,120.65 34.6,120.65 32.97,119.02 32.77,119.02 32.4,118.65 32.4,118.65 32.22,118.47 29.52,118.47 28.37,117.32 28.37,115.73 26.84,114.2 25.4,114.2 20.73,109.53 v2(19.69,109.53)
3D3V_LCDVDD_S0: length 36.9
  TOP w0.305: v2(224.11,68.43) 224.11,69.01 C5530.1 223.01,69.06 D5505.A
  L6 w0.305: v2(224.11,68.43) 224.72,67.82 224.72,49.88 224.55,49.71 224.23,49.4 224.23,48.12 225.07,47.29 225.07,44.69 222.3,41.93 222.3,40.97 220.22,38.89 218.44,38.89 v4(217.81,39.52)
  vias: v2(210.34,53.52) v2(217.15,39.88) v4(209.6,53.49)
3D3V_MUX: length 40.7
  TOP w0.203: U7101.20 23.94,108.45 23.88,108.51 v2(23.88,108.51) ; U7101.28 20.24,108.73 v2(20.04,108.54) ; U7101.6 v2(22.6,102.16)
  TOP w0.254: v1(20.04,98.99) 20.65,99.59 R7152.1 20.15,99.9 R7147.1 19.03,100.23 19,100.26 v2(18.37,100.26) ; v2(25.63,113.46) 25.63,113.67 26.17,114.2 R7101.1
  L3 w0.254: v2(18.37,100.26) 20.88,100.26 22.6,101.97 v2(22.6,102.16)
  BOTTOM w0.254: 19.21,107.16 18.65,107.72 R7189.1 L7101.2 ; 19.21,107.16 R7190.1 19.21,106.27 R7140.1 18.14,105.21 18.14,103.53 18.42,103.25 R7142.1 18.88,103.25 19.48,103.86 20.83,103.86 21.21,103.48 21.21,103.2 21.54,102.87 C7115.2 C7117.2 22.51,102.25 v2(22.6,102.16) 23.21,102.77 R7145.1 R7171.1 ; 19.21,107.16 C7116.2 v2(20.04,108.54) 21.03,108.54 C7119.1 21.77,109.17 22.74,109.17 ; R7174.1 23.88,107.85 v2(23.88,108.51) 23.83,108.56 C7118.2 22.74,109.17 ; v2(18.37,100.26) 19.1,100.26 R7175.1 ; 22.74,109.17 23.57,110.01 23.57,110.9 25.63,112.96 v2(25.63,113.46)
3D3V_MUX2: length 2.4
  TOP w0.203: U7102.13 33.04,120.18 33.41,120.55 33.51,120.55 33.94,120.98 C7120.1
  TOP w0.254: C7120.1 34.62,121.01 R7126.2
3D3V_MUX_VCC: length 4.3
  TOP w0.254: U7101.1 19.91,102.86 19.79,102.97 v1(19.38,102.97) 19.38,102.42 19.26,102.29 C7165.2 18.39,101.02 v2(18.37,101.02)
  BOTTOM w0.254: R7175.2 v2(18.37,101.02)
3D3V_RTC: length 246.3
  TOP w0.305: v2(19.18,14.91) 19.28,14.81 R2708.1
  TOP w0.356: v1(177.7,53.27) v2(178.26,53.27)
  TOP w0.508: D2501.3 161.07,90.3 v2(161.09,90.32) 161.77,90.32 Q2507.S ; v2(148.85,37.52) 143.01,31.68 133.39,31.68 130.57,34.49 129.77,34.49 129.29,34.98 v2(128.07,34.98)
  L3 w0.508: v2(178.26,53.27) 177.55,53.98 177.55,58.72 179.4,60.57 179.4,62.36 178.82,62.94 178.82,65.27 173.02,71.07 173.02,73.25 171.36,74.9 171.36,75.3 170.79,75.87 v2(170.79,76.58)
  L5 w0.508: v2(170.79,76.58) 170.49,76.28 169.95,76.28 166.12,80.1 166.12,84.46 163.79,86.79 163.79,88.05 161.52,90.32 v2(161.09,90.32) ; v2(178.26,53.27) 178,53.27 176.99,52.26 176.99,44.79 173.43,41.23 173.43,40.51 173.11,40.18 169.91,40.18 167.69,37.96 156.68,37.96 156.24,37.52 v2(148.85,37.52)
  L6 w0.305: v2(128.07,34.98) 124.85,38.2 124.29,38.2 121.08,41.4 113.13,41.4 112.27,40.54 112.27,34.5 111.23,33.46 111.23,31.78 109.17,29.72 108.14,29.72 107.05,28.63 97.97,28.63 96.96,29.64 91.44,29.64 89.72,27.92 45.72,27.92 45.42,27.61 41,27.61 33.94,20.55 29.72,20.55 28.53,19.36 24.27,19.36 19.82,14.91 v2(19.18,14.91)
  BOTTOM w0.508: v2(161.09,90.32) 161.09,90.91 161.55,91.37 161.34,91.57 R2472.2
3D3V_RTC_AUX_S5: length 28.4
  TOP w0.508: v2(164.07,92.89) 164.07,92.14 R2506.2 163.91,91.75 Q2507.D ; v2(168.28,79.55) 168.28,78.11 168.1,77.93 v1(168.1,77.9) 168.1,74.18 168.16,74.12 168.16,73.22 167.76,72.81 167.76,69.79
  L6 w0.508: v2(164.07,92.89) 164.07,90.49 165.1,89.46 165.1,85.4 166.22,84.28 166.22,83.13 166.27,83.08 166.27,81.56 v2(168.28,79.55)
  BOTTOM w0.508: R2476.2 163.74,93.22 v2(164.07,92.89)
3D3V_RTC_SYS: length 3.3
  TOP w0.508: R2505.2 160.38,94.06 v1(160.79,93.65) 160.43,93.3 R2517.1 159.82,93.01 D2501.1
3D3V_S0: length 524.3
  TOP w0.203: U5802.30 55.5,119.63 55.78,119.92 55.78,120.11 56.02,120.35 56.72,120.35 v2(56.87,120.5) ; v2(46.18,120.11) 45.92,120.11 45.37,119.56 C5810.2 45.37,119.51 45.8,119.51 45.92,119.63 U5802.51 ; U5802.5 48.5,114.95 48.23,114.67 v2(48.22,114.67) ; v2(55.84,116.1) 55.88,116.06 C5812.1 55.58,115.27 55.04,115.81 U5802.21 ; U5802.57 45.92,117.23 45.62,116.93 45.62,116.68 45.3,116.36 44.78,116.36 44.66,116.23 44.66,115.83 C5811.1
  TOP w0.254: 223.78,43.77 223.57,43.56 R5518.1 ; 223.78,43.77 223.78,46.41 v2(224.41,47.04) ; 223.78,43.77 224.77,43.77 225.15,43.38 R5517.1 ; v2(215.42,62.84) 213.9,64.36 R2043.1 ; v2(33.35,41.66) 33.71,41.66 R1822.1 ; v2(155.84,103.57) 155.53,103.89 R5564.2 ; v2(42.5,117.2) 43.13,117.2 R5807.1 43.56,117.22 R5811.1 ; v4(43.51,114.71) 43.56,114.66 R5815.1 ; v2(131.24,31.94) 131.24,32.6 EC8992.1 ; R5815.1 44.53,114.4 R5817.1 44.78,113.64 R5834.1 ; R5815.1 C5811.1 ; R2044.1 138.07,92.7 138.46,93.09 v2(138.83,93.09) ; R1617.1 196.27,35.74 v2(196.47,35.54) ; 34.01,101.68 v2(34.01,103.53) ; 34.01,101.68 Q5801.5 ; 34.01,101.68 Q5801.2
  TOP w0.305: R2467.2 43.58,54.1 U2402.5 44.21,55.76 ; R1310.2 151.82,43.56 152.23,43.16 ; v2(123.59,97.3) 121.88,97.3 120.81,98.37 v2(120.42,98.37) ; v2(49.36,73.15) 47.7,71.5 46.49,71.5 Q2414.G 45.61,71.2 44.97,71.85 43.84,71.85 42.51,70.51 R2489.2 ; DBG1.10 32.55,53.46 32.85,53.75 v2(32.9,53.75) ; 33.65,21.92 33.65,21.16 32.94,20.45 32.25,20.45 R6415.1 ; v2(204.17,60.45) 204.17,60.48 R2059.1 ; v2(216.28,49.91) 215.85,49.48 R2046.1 ; v2(160.28,82.07) 160.28,82.78 160.83,83.33 U9103.8 ; v2(116.62,97.39) 116.84,97.61 116.84,97.63 117.1,97.88 R2048.1 R2065.1 R2066.1 115.42,98.3 R2049.1 ; PR8634.2 110.87,153.54 110.37,154.05 110.37,154.71 109.76,155.32 106.84,155.32 v2(106.33,154.81) ; R8806.1 107.37,141.05 v4(107.8,140.62) ; v2(77.73,41.58) 77.73,41.43 77.3,41 EC8995.1 76.2,40.84 R1211.2 ; R8703.2 102.8,142.09 v2(102.52,141.81) 101.86,142.47 C8807.1 101.53,142.5 100.41,142.5 99.81,141.9 U8802.5 ; Q5702.5 Q5702.2 21.97,91.03 20.88,92.13 v2(19.82,92.13) ; v2(29.06,22.53) 29.19,22.66 R6411.1 29.98,22.96 29.98,23.78 29.44,24.31 R6348.1 ; v2(109.02,28.47) 108.87,28.63 R507.1 109.12,29.36 EC8993.1 ; R2430.2 26.44,57.33 25.71,56.59 v2(25.56,56.59) ; EC8953.1 EC8980.1 89.36,29.69 ; v2(56.87,120.5) 57.74,120.5 R5822.1
  TOP w0.381: C1228.1 95.84,47.09 95.46,47.47 95.46,48.9 95.83,49.27 v2(96.13,49.27) ; v2(26.32,95.15) 26.46,95.15 30.19,98.88 v2(36.91,98.88) 37.37,98.88 39.32,96.93 R1827.1 41.34,96.95 v1(47.35,96.95) 49.91,96.95 50.93,95.94 51.05,95.94 51.06,95.93 51.94,95.93 52.26,95.61 v2(52.4,95.61)
  TOP w0.508: v2(43.64,120.8) R5813.1 R5809.1 ; v2(160.28,82.07) 160.02,82.32 C9104.1 159.38,82.32 159.15,82.09 159.13,82.09 158.91,81.87 158.91,81.16 158.75,81.01 158.75,80.24 159.36,79.63 R2053.1 157.69,79.3 157.56,79.43 152.4,79.43 v2(150.55,77.57) 150.55,77.34 152.87,75.02 R1820.1 152.85,73.76 R1823.1 152.06,73.79 R1825.1 ; v2(41.58,61.11) 46.01,56.69 46.01,56.47 ; R2715.1 28.53,22.4 28.66,22.53 v2(29.06,22.53) ; v2(215.42,62.84) 216.08,63.5 218.6,63.5 219.58,62.51 221.95,62.51 222.78,63.35 ; R1204.2 95.3,46.18 95.48,46.36 v2(95.48,46.46) C1228.1 R1208.2 ; 44.21,55.76 44.92,56.47 46.01,56.47 ; v2(224.41,47.04) 224.41,48.27 223.52,49.15 223.52,61.55 224.54,62.56 224.54,63.35 ; 46.01,56.47 C2432.1 ; 126.16,111.61 125.61,111.05 125.61,108.33 127.26,106.68 127.26,104.37 127.58,104.05 v2(127.58,103.06) 126.45,103.06 125.96,102.57 125.96,98.68 126.26,98.38 v2(127.03,98.38) 127.32,98.09 127.32,96.35 v2(127.45,96.22) ; v2(99.22,30.24) 99.22,30.28 99.27,30.33 R6502.1 ; v2(32.93,21.92) 33.65,21.92 34.39,22.66 34.39,22.73 40.62,28.96 42.85,28.96 ; v2(202.64,57.81) 202.64,58.03 201.76,58.9 193.65,58.9 v2(192.87,58.12) ; v2(96.13,49.27) 95.96,49.44 R1216.1 ; R4010.1 v1(88.6,33.63) 88.6,30.46 90.62,28.43 v4(91.13,28.43) ; v2(106.33,154.81) 106.33,154.2 105.78,153.66 R8705.2
  TOP w1.016: v4(117.77,130.07) 116.67,130.07 115.7,129.1 115.7,128.26 116.63,127.33 118.39,127.33 123.55,122.18 123.55,121.06
  L3 w0.305: v2(116.62,97.39) 116.91,97.11 118.9,97.11 120.16,98.37 v2(120.42,98.37)
  L3 w0.508: v2(93.68,153.82) 94.51,153.82 96.03,155.35 105.8,155.35 106.33,154.82 v2(106.33,154.81) 106.33,152.3 103,148.97 103,146.85 103.45,146.41 v2(103.61,146.41) ; 95.02,43.66 95.38,44.02 95.38,45.72 95.48,45.82 v2(95.48,46.46) ; v2(123.96,99.24) 123.82,99.24 123.14,98.56 123.14,97.75 v2(123.59,97.3) ; v3(165.92,74.07) v3(166.6,74.07) 166.6,72.92 166.8,72.72 166.8,71.91 171.67,67.04 173.95,67.04 176.6,64.39 176.6,60.86 175.43,59.69 175.43,59.34 175.43,56.47 175.54,56.35 v4(175.54,54.23) 175.54,53.42 v4(175.57,53.39) ; 41.58,55.6 v2(41.58,61.11) ; v2(192.87,58.12) 192.73,58.25 179.38,58.25 178.95,57.81 v2(178.18,57.81)
  L5 w0.254: v2(34.01,103.53) 34.01,101.78 v2(36.91,98.88)
  L5 w0.305: v2(132.39,91.57) 132.39,92.13 133.56,93.3 133.56,94.92 134.05,95.41 134.05,96.43 133.07,97.41 v2(132.56,97.41)
  L5 w0.508: v2(26.32,95.15) 26.32,93.62 25.2,92.5 21.66,92.5 21.29,92.13 v2(19.82,92.13) ; v4(175.54,54.23) 175.54,57.24 176.12,57.81 v2(178.18,57.81) ; v2(93.68,153.82) 93.12,153.26 93.12,152.44 92.48,151.79 92.03,151.79 91.67,151.43 84.66,151.43 82.92,153.17 v2(82.92,154.84) ; v2(160.28,82.07) 160.28,84.53 159.39,85.42 159.39,90.43 158.75,91.06 158.75,94.84 157.31,96.29 157.31,98.63 156.37,99.57 156.26,99.57 v2(155.95,99.89) 156.98,100.92 156.98,102.44 v2(155.84,103.57) 153.14,106.27 v2(153.14,106.78)
  L6 w0.305: v2(224.41,47.04) 222,47.04 220.17,48.87 218.47,48.87 217.43,49.91 v2(216.28,49.91)
  L6 w0.508: v2(16.59,105.36) 17.23,105.36 20.45,102.14 20.45,97.39 20.32,97.27 20.32,95.28 20.63,94.97 20.63,92.94 v2(19.82,92.13) ; v2(215.42,62.84) 215.42,62.76 214.43,61.77 205.35,61.77 204.17,60.59 v2(204.17,60.45) ; v2(32.93,21.92) 32.93,21.6 32.41,21.08 31.02,21.08 29.57,22.53 v2(29.06,22.53)
  L6 w1.016: v4(117.77,130.07) 115.52,132.31 115.52,137.38 114.37,138.53 111.48,138.53 110.82,139.19 109.22,139.19 v4(107.8,140.62) 106.61,141.81 v2(102.52,141.81)
  BOTTOM w0.254: PR8530.1 140.1,80 v2(139.42,80) ; v2(128.3,113.13) 127.99,113.44 R2618.1 127.59,113.34 126.77,113.34 126.77,113.34 R2617.1 ; R1826.1 R3109.1 ; v2(103.61,146.41) 103.99,146.41 104.3,146.1 R8701.2 R8708.2
  BOTTOM w0.279: DM2.255 172.03,52.11 v2(172.32,52.4) ; v2(96.13,49.27) 95.83,49.58 DM1.255
  BOTTOM w0.305: Q6504.2 Q6504.5 98.58,30.91 99.22,30.28 v2(99.22,30.24) ; 203.45,59.56 204.17,60.28 v2(204.17,60.45) ; U7302.5 v4(137.53,97.78) ; v2(102.52,141.81) 102.59,141.89 R8710.2 ; v2(49.88,79.26) 49.88,79.24 v1(49.3,78.67) 49,78.97 48.63,78.97 R3109.1 ; Q2601.2 132.19,109.01 v2(132.47,109.01) ; Q1801.2 124.51,96.53 123.74,97.3 v2(123.59,97.3) ; v2(132.39,91.57) 132.26,91.44 R2064.1 ; v2(129.9,111.46) 129.9,111.3 Q2601.5 ; Q1801.5 127.14,96.53 v2(127.45,96.22) 127.51,96.16 R2008.1 ; EC8950.1 EC8977.1 52.33,95.53 v2(52.4,95.61) ; R407.2 R2010.1 123.37,100.05 123.96,99.47 v2(123.96,99.24)
  BOTTOM w0.508: v2(25.56,56.59) 26.39,56.59 27.37,55.61 27.37,55.53 27.7,55.2 27.7,49.19 v2(28.63,48.26) ; v2(82.92,154.84) PR4609.1 R4005.1 ; PR8611.1 v2(106.33,154.81) ; R5557.1 153.67,107.53 153.14,106.99 v2(153.14,106.78) ; R5501.1 156.06,100 v2(155.95,99.89) ; v2(16.59,105.36) 17.39,105.36 Q5703.C ; v2(132.56,97.41) 131.07,97.41 130.35,98.13 R1824.1 129.27,98.4 127.05,98.4 v2(127.03,98.38) 125.14,98.38 124.29,99.24 v2(123.96,99.24)
  vias: v1(55.17,117.73) v1(149.41,33.83) v2(43.44,28.62) v2(44.08,28.62) v2(44.72,28.62) v2(54.79,41.58) v2(55.5,41.58) v2(56.24,41.58) v2(113.11,27.94) v2(130.17,96.09) v2(130.61,31.9) v2(197.13,35.54) v3(149.33,32.72) v3(150.02,32.72) v4(43.49,113.84) v4(43.67,129.77) v4(43.92,131.5) v4(43.89,130.63) v4(44.55,129.8) v4(44.81,131.5) v4(44.78,130.63) v4(44.96,116.94) v4(45.34,102.82) v4(45.6,115.52) v4(46.18,102.8) v4(91.76,29.01)
3D3V_S5: length 385.5
  TOP w0.152: R6611.1 156.72,106.1 156.92,105.89 156.92,103.18
  TOP w0.254: v2(108.41,28.07) 108.23,28.24 R2498.1 ; v2(16.23,64.29) 16.91,64.29 17.88,65.26 17.88,66.32 v2(19.09,67.53) ; RN2405.3 20.65,73.3 v2(20.3,72.95) 20.6,72.65 RN2405.4 ; 165.43,72.42 165.88,72.87 166.42,72.87 166.8,72.49 R9212.1
  TOP w0.305: PG4530.2 62.07,130.14 61.09,129.16 58.02,129.16 ; U9103.1 165.24,84.01 v2(165.31,84.08) ; v2(165.87,78.54) 166.63,78.54 166.91,78.82 R1739.2 ; 206.39,44.57 206.26,44.71 v2(206.26,45.53) ; 206.39,44.57 PR4472.1 ; 206.39,44.57 206.26,44.44 206.26,43.7 PR4450.2 ; R1910.1 148.76,73.77 148.29,73.3 v2(148.29,72.7) ; v4(56.98,93.09) 60.66,93.09 61.42,93.85 R6102.1 ; PR4431.1 15.83,129.67 v2(15.4,130.1) ; R2607.1 41.94,69.11 42.35,68.7 42.35,68.62 42.42,68.55 v2(42.42,68.45) EC8941.1 ; R7126.1 v2(34.7,122.45) ; R5547.2 45.47,64.21 EC8944.1 45.4,63.65 v2(44.3,63.65) ; R7427.1 31.14,115.9 31.4,116.16 v2(31.4,116.56) ; v2(44.8,80.17) 43.68,79.05 42.55,79.05 42.04,78.54 42.04,78.28 41.35,77.6 R6404.2 40.77,77.6 40.24,77.6 R2442.1 ; R4304.1 26.32,94.06 D4302.2 v2(25.07,93.36)
  TOP w0.381: R7216.1 56.24,135.05 FC8911.1 55.64,134.55 54.54,133.45 54.36,133.45
  TOP w0.406: R4378.1 37.46,117.44 U4302.2 40.28,117.44 v4(40.34,117.5)
  TOP w0.508: R4048.1 88.6,35.66 v2(88.7,35.56) ; R1721.1 v2(145.23,72.7) ; v2(38.1,119.46) 38.39,119.74 R7424.1 ; PR5101.1 109.21,27.73 108.75,27.73 v2(108.41,28.07) ; 164.8,73.18 165.43,72.54 v2(165.43,72.37) ; 164.8,73.18 164.63,73.18 163.87,72.42 163.87,71.18 165.18,69.87 Q9201.S ; 164.8,73.18 164.8,73.28 165.26,73.74 165.26,74.74 165.88,75.36 166.75,75.36 167.34,75.95 167.34,77.32 166.88,77.78 166.63,77.78 v2(165.87,78.54) ; v2(93.48,28.6) 93.48,29.97 94.19,30.68 94.19,31.65 ; 17.7,70.69 17.7,72.15 18.49,72.95 v2(20.3,72.95) ; v4(50.68,132.28) 50.8,132.28 51.97,133.45 54.36,133.45
  TOP w0.762: v2(165.03,93.83) 164.34,94.51 162.21,94.51 160.39,96.33 160.39,96.97 158.55,98.81 158.55,100.13 158.52,100.16 158.52,100.17 156.62,102.08 156.62,102.87 157.58,103.84 157.8,103.84 159.68,105.72 161.06,105.72 162.69,107.34 R8601.1
  L3 w0.508: v2(108.41,28.07) 108.09,28.39 105.96,28.39 105.54,27.97 93.85,27.97 93.48,28.34 v2(93.48,28.6) ; v2(18.09,109.53) 18.09,108.31 19.15,107.24 19.15,106.66 18.67,106.17 18.67,104.13 19.4,103.4 22.48,103.4 23.42,102.46 23.42,100.97 22.71,100.26 22.71,97.63 25.07,95.27 v2(25.07,93.36)
  L3 w0.762: 199.28,60.41 184.34,60.41 180.95,63.81 180.95,66.93 178.92,68.96 177.59,68.96 175.89,70.67 175.89,72.51 174.68,73.71 174.68,74 172.09,76.59 170.9,77.78 169.11,77.78 168.34,78.54 v2(165.87,78.54) 165.31,79.1 v2(165.31,84.08) 165.31,84.78 164.65,85.44 164.65,91.49 165.03,91.87 v2(165.03,93.83)
  L5 w0.508: 21.36,128.17 21.36,121.08 20.15,119.86 18.79,119.86 16.31,117.38 16.31,113.92 17.5,112.73 17.5,112.16 17.5,110.42 18.09,109.83 v2(18.09,109.53) ; 21.36,128.17 22.18,128.98 26.75,128.98 28.88,131.12 28.88,132.61 30.09,133.82 35.09,133.82 v2(35.31,134.04) ; 21.36,128.17 20.55,128.98 16.36,128.98 15.4,129.95 v2(15.4,130.1) ; v2(42.42,68.45) 42.42,70.89 44.8,73.27 v2(44.8,80.17)
  L6 w0.305: v2(206.26,45.53) 206.42,45.53 206.81,45.92 206.81,46.94 207.72,47.85 207.72,48.54 208.94,49.76 v3(208.94,49.99) ; v4(40.34,117.5) 40.26,117.5 39.83,117.07 34.72,117.07 34.42,116.77 31.6,116.77 v2(31.4,116.56)
  L6 w0.508: v2(9.99,112.65) 10.16,112.83 12.6,112.83 14.48,110.95 16.97,110.95 18.09,109.83 v2(18.09,109.53)
  BOTTOM w0.203: v2(19.09,67.53) 19.14,67.58 19.34,67.58 20.67,68.91 21.8,68.91 22.94,67.77 R2492.1
  BOTTOM w0.254: L7101.1 17.88,109.32 v2(18.09,109.53) ; R2434.1 v2(16.23,64.29) ; R2514.1 R2520.1 155.07,94.29 U2502.5 ; U5501.5 208.94,49.11 208.4,49.11 208,48.71 PR4435.1 ; v2(93.48,28.6) 92.51,29.57 92.51,32.28 92.89,32.67 C6502.1 R2499.1 ; R2495.1 23.19,72.21 23.42,72.44
  BOTTOM w0.305: Q2416.5 Q2416.2 23.57,73.5 23.42,73.35 23.42,72.44 ; R506.1 102.75,37.31 v2(102.75,36.88) ; U4007.5 90.38,39.29 90.38,38.51 88.8,36.93 88.8,35.66 v2(88.7,35.56) ; 23.42,72.44 24.06,72.44 25.02,73.4 25.8,73.4 26.93,74.53 26.93,75.48 27.62,76.18 33.19,76.18 33.66,76.65 37.18,76.65 37.8,77.27 39.96,77.27 40.59,77.9 41.56,77.9 v1(41.94,78.28) 42.91,78.28 v2(44.8,80.17) ; 23.42,72.44 20.81,72.44 v2(20.3,72.95) ; v2(38.1,119.46) 38.26,119.61 38.26,121 37.46,121.79 35.36,121.79 v2(34.7,122.45)
  BOTTOM w0.406: v4(40.34,117.5) 39.31,117.5 38.1,118.71 v2(38.1,119.46)
  BOTTOM w0.508: v2(145.23,72.7) v2(148.29,72.7) 148.29,72.51 149.08,71.72 164.79,71.72 v2(165.43,72.37) ; PR4432.2 v2(9.99,112.65) ; Q6502.S 93.48,27.87 v2(93.48,28.6) ; U2502.5 156.44,95.66 157.88,95.66 159.38,94.16 159.91,94.16 160.26,94.51 161.44,94.51 161.97,93.98 164.87,93.98 v2(165.03,93.83)
  vias: v2(75.14,38.48) v2(75.8,38.46) v2(94.49,36.35) v2(95.25,37.39) v2(95.26,36.32) v2(95.25,35.15) v2(96.07,36.32) v2(99.65,37.73) v2(149.76,64.72) v2(200.33,60.48) v2(201.09,60.48) v2(201.86,60.48) v2(202.62,60.48) v3(216.87,47.8) v3(216.87,47.04) v4(48.34,131.19) v4(48.95,133.48) v4(49.05,131.7) v4(49.08,130.79) v4(49.81,133.48) v4(49.81,131.29) v4(49.92,132.65) v4(50.62,133.25) v4(53.2,102.94) v4(53.84,103.57) v4(54.94,129.03) v4(55.69,93.47) v4(55.7,92.63) v4(56.39,93.93) v4(56.51,92.37) v4(57.36,129.87) v4(57.36,128.98) v4(101.15,35.21) v4(103.23,41.38) v4(150.47,64.95) v4(151.33,64.82) v4(209.01,50.8)
3D3V_S5_PCH: length 361.6
  TOP w0.254: v2(212.6,58.9) 212.55,58.95 R2061.1 ; R6877.2 84.46,36.04 v2(84.43,36.02) ; R2068.1 213.67,51.33 v2(214.07,50.93)
  TOP w0.305: R2047.1 155.63,39.73 v2(155.63,40.23)
  TOP w0.508: v2(153.02,109.7) 153.7,109.02 153.7,107.35 154.56,106.48 154.56,102.12 154.44,101.99 154.44,101.36 155.07,100.73 R2516.2 155.79,98.91 v2(155.82,98.88) ; v2(123.6,96.54) 120.97,96.54 v2(120.42,97.1) ; R2119.1 131.85,79.14 R2521.1 132.02,82.61 131.85,82.78 131.85,84.82 132.25,85.22 v2(132.49,85.22) ; v2(127.94,105.56) 127.94,105.49 128.38,105.05 R2055.1 128.79,104.45 128.21,103.88 128.21,102.8 127.78,102.36 v2(127.56,102.36) 126.98,101.78 126.98,101.04 127.69,100.33 127.69,99.48 127.32,99.11 v2(127.05,99.11) ; R1506.1 163.04,75.74 R9148.1 163.07,75.61 163.07,75.11 v2(162.94,74.98) ; R1837.1 138.41,70.51 R1502.1 138.72,71.03 139.98,72.29 139.98,73.92 138.61,75.29 v2(138.61,76.35)
  L3 w0.254: v2(130.32,41.22) 129.65,41.9 111.83,41.9 108.02,38.09 v2(106.99,38.09)
  L3 w0.508: v2(176.28,57.08) 176.28,59.34 177.45,60.5 177.45,64.75 174.3,67.9 172.84,67.9 169.04,71.7 169.04,72.66 168.13,73.57 168.13,74.46 166.84,75.74 163.71,75.74 v2(162.94,74.98) ; v2(216.11,42.32) 216.11,42.42 213.37,45.15 213.37,50.23 v2(214.07,50.93) ; v2(124.44,101.86) 125.05,101.25 125.05,97.86 123.73,96.54 v2(123.6,96.54) v2(123.6,92.79) 123.61,92.79 124.23,92.16 124.23,90.31 122.62,88.7 v2(122.46,88.7)
  L5 w0.254: v2(139.32,41.25) 138.59,41.25 136.59,39.26 131.48,39.26 130.32,40.42 v2(130.32,41.22) ; v2(84.43,36.02) 84.56,36.15 90.7,36.15 91.23,35.61 92.97,35.61 94.21,36.86 96.4,36.86 97.03,36.22 106.11,36.22 106.68,36.8 106.68,37.79 v2(106.99,38.09)
  L5 w0.508: v2(176.28,57.08) 176.28,57 177.55,55.72 ; 177.55,55.72 176.36,54.53 176.36,48.44 175.44,47.52 175.44,44.14 173.04,41.73 172.45,41.73 171.53,40.82 169.65,40.82 167.43,38.6 156.78,38.6 155.63,39.75 v2(155.63,40.23) ; 177.55,55.72 179.78,53.49 191.39,53.49 192.74,54.84 197.05,54.84 197.11,54.78 197.12,54.78 197.49,54.4 197.49,54.4 197.73,54.15 201.4,54.15 201.42,54.17 204.17,54.17 206.99,57 208.05,57 209.96,58.9 v2(212.6,58.9) 212.73,59.03 213.3,59.03 214.06,58.27 215.22,58.27 216.16,57.33 216.16,53.16 214.07,51.08 v2(214.07,50.93) ; v2(155.82,98.88) 156.04,98.88 156.21,98.71 156.22,98.71 156.59,98.33 156.59,92.24 158.75,90.08 158.75,77.18 157.94,76.37 v2(157.47,76.37) 157.47,76.34 157.03,75.9 156.5,75.9 156.37,76.02 142.81,76.02 142.56,75.77 142.03,75.77 142.03,75.77 140.02,75.77 140.01,75.78 139.29,75.78 138.71,76.35 v2(138.61,76.35)
  L6 w0.508: v2(162.94,74.98) 161.56,76.37 v2(157.47,76.37) ; v2(138.61,76.35) 136.13,76.35 133.12,79.36 133.12,84.82 132.73,85.22 v2(132.49,85.22)
  BOTTOM w0.203: R1508.1 134.06,89.82 R2515.1 133.76,89.87 133.3,89.41 133.3,86.03 v2(132.49,85.22)
  BOTTOM w0.254: v2(155.63,40.23) 155.63,40.54 154.73,41.44 139.51,41.44 v2(139.32,41.25) ; R2062.1 v2(214.07,50.93)
  BOTTOM w0.305: RN1811.1 152.7,110.02 v2(153.02,109.7) 152.66,109.35 RN1811.2 ; 128.3,85.22 127.51,84.42 R6609.1 R1510.1 ; R2060.1 215.95,42.47 v2(216.11,42.32)
  BOTTOM w0.356: v2(123.6,92.79) 123.24,92.79 v1(123.07,92.97)
  BOTTOM w0.508: R406.1 127.31,99.11 v2(127.05,99.11) ; v2(120.42,97.1) 120.15,97.1 120.13,97.12 119.86,97.12 R1551.1 119.57,97.88 R1504.1 119.56,98.21 R2041.1 ; v2(123.6,92.79) 123.61,92.78 R1554.1 ; v2(124.44,101.86) 124.84,101.86 125.09,102.11 126.06,102.11 126.29,102.34 R405.1 126.52,102.36 v2(127.56,102.36) ; v2(122.46,88.7) 123.03,88.12 R1103.1 126.75,87.63 R1513.1 R1522.1 126.75,86.03 127,85.78 R2519.1 128.07,85.22 v2(132.49,85.22)
3D3V_S5_PCH_R:
  vias: v1(130.46,100.1)
3D3V_SPIVCC1: length 28.6
  TOP w0.254: v2(132.24,89.66) 132.24,88.62 v1(132.51,88.34) 133,88.34 133.23,88.57 133.52,88.57 133.75,88.34 BIOS2.8
  L5 w0.254: v2(132.85,76.98) 132.68,76.98 131.9,77.76 131.9,89.33 v2(132.24,89.66)
  BOTTOM w0.254: BIOS1.8 128.94,80.93 128.43,80.42 128.43,79.91 128.17,79.66 C2502.1 128.53,79.22 C2501.1 129.44,79.86 129.82,79.48 129.82,79.04 130.03,78.84 130.03,78.16 131.21,76.98 v2(132.85,76.98) ; v2(132.24,89.66) 132.69,89.66 133.76,90.73 R2515.2
3D3V_SSD:
  vias: v1(20.04,24) v2(18.72,22.71) v2(19.38,22.68)
3D3V_TP_CT2: length 1.8
  BOTTOM w0.089: U5503.10 159.09,105.79 C5540.1 159.62,106.12 v1(159.62,106.55)
3D3V_TPM: length 13.6
  TOP w0.305: U9103.22 164.24,77.56 v2(164.21,77.52)
  TOP w0.508: v2(159.79,77.76) 159.45,77.42 v1(159.45,76.81) R9119.2
  BOTTOM w0.305: v2(164.21,77.52) 163.85,77.17 160.39,77.17 v2(159.79,77.76)
  BOTTOM w0.381: C9112.1 C9113.1 162.77,78.33 C9109.1 ; C9112.1 164.34,77.65 v2(164.21,77.52) ; C9112.1 165.08,78.33 R9149.2
  BOTTOM w0.508: C9109.1 162.06,78.54 161.55,79.05 R9150.2
3D3V_VCCDSW: length 177.8
  TOP w0.254: C2230.1 101.98,92.42 v2(101.98,92.27)
  TOP w0.508: v2(174.7,72.05) 174.7,71.37 175.02,71.06 175.02,67.51 174.15,66.65 174.15,64.07 174.27,63.95 174.27,61.95 173.4,61.08 169.57,61.08 169.26,61.39 167.77,61.39 v2(167.64,61.27) ; v2(155.82,98.05) R2516.1
  L5 w0.305: 112.19,90.85 111.82,91.22 109.74,91.22 109.38,91.59 109.38,91.66 108.83,92.21 104.14,92.21 103.53,92.82 102.44,92.82 101.98,92.36 v2(101.98,92.27)
  L5 w0.508: 112.19,90.85 112.88,90.16 112.88,84.66 113.26,84.28 113.26,84.02 113.36,83.92 113.36,80.76 113.26,80.65 113.26,75.96 122.24,66.98 122.24,65.25 126.29,61.2 158.94,61.2 159.43,60.72 167.1,60.72 v2(167.64,61.27)
  L6 w0.508: v2(174.7,72.05) 174.7,72.5 174.05,73.15 173.07,73.15 169.18,77.04 168.38,77.04 164.7,80.72 164.7,82.27 163.26,83.71 163.26,89.11 161.16,91.21 158.12,91.21 155.82,93.51 v2(155.82,98.05)
  BOTTOM w0.305: CPU1.BT23 101.98,92.36 v2(101.98,92.27) 101.98,92.17 CPU1.BR24
  BOTTOM w0.508: v2(144.21,72.71) 146.03,70.89 174.09,70.89 174.7,71.5 v2(174.7,72.05)
  vias: v1(141.71,72.52)
3D3V_VCCPRIM: length 15.1
  TOP w0.305: C2202.1 105.93,96.45 v2(105.9,96.47)
  L3 w0.305: 121.9,92.1 121.69,92.3 121.69,95 121.08,95.61 121.08,97.21 120.56,97.73 v2(120.42,97.73)
  BOTTOM w0.254: CPU1.CP29 113.3,89.03 v2(114.29,89.03)
  BOTTOM w0.305: CPU1.BW23 104.28,92.78 103.95,93.11 v2(103.95,93.15) 103.93,93.14 103.93,93.11 103.63,92.8 CPU1.BV23 ; CPU1.BT20 101.99,94.05 v2(101.99,93.98) ; CPU1.CB16 105.9,96.58 v2(105.9,96.47) ; R1731.1 120.1,100.13 R1701.1 120.09,99.47 120.96,98.6 v1(120.96,97.94) 120.75,97.73 v2(120.42,97.73) ; CPU1.BP23 101.03,92.78 v2(101.35,93.1)
  vias: v2(106.53,93.14) v2(107.2,93.1) v2(122.3,89.59)
3D3V_VCCPRTC: length 95.4
  TOP w0.254: 101.86,91.72 101.81,91.72 101.34,92.19 v2(101.34,92.31)
  TOP w0.508: v2(165.2,61.98) 165.2,62.74 v1(164.67,63.28) 164.21,63.73 164.21,66.68 164.67,67.14
  L5 w0.305: 112.1,93.37 111.66,93.37 111.65,93.38 107.85,93.38 107.56,93.67 105.79,93.67 105.58,93.46 104.79,93.46 104.27,93.98 103.45,93.98 102.87,93.4 102.39,93.4 101.34,92.36 v2(101.34,92.31)
  L5 w0.508: 112.57,93.84 112.1,93.37 ; 117.1,93.3 117.1,90.87 114.94,88.71 114.94,87.87 115.39,87.42 115.39,82.22 116.28,81.32 116.28,74.42 123.27,67.44 123.27,65.68 126.64,62.31 161.62,62.31 161.9,62.59 164.47,62.59 165.08,61.98 v2(165.2,61.98)
  BOTTOM w0.305: CPU1.BR23 101.34,92.37 v2(101.34,92.31)
3D3V_WLAN:
  vias: v2(49.53,106.3) v4(31.5,103.3) v4(31.5,102.41) v4(48.72,106.33) v4(57.58,93.98) v4(58.42,94.41)
27MHZ_IN: length 27.3
  BOTTOM w0.102: X7901.1 157.01,110.39 155.87,110.39 R7903.1 155.07,110.78 154.44,110.78 C7907.2 154.25,110.8 153.65,110.8 151.3,113.15 151.3,113.67 150.7,114.27 150.7,115.68 149.94,116.45 145.73,116.45 142.75,119.43 142.5,119.43 139.3,122.63 138.92,122.63 138.26,123.3 GPU1.C11
27MHZ_OUT: length 23.3
  BOTTOM w0.102: R7903.2 R7904.2 153.89,110.57 153.56,110.57 151.07,113.05 151.07,113.58 150.47,114.18 150.47,115.59 149.84,116.22 145.64,116.22 142.66,119.2 142.4,119.2 139.2,122.4 138.83,122.4 138.61,122.63 138.23,122.63
27MHZ_OUT_R: length 2.3
  BOTTOM w0.114: R7904.1 154.44,109.36 C7908.2 156.04,109.36 X7901.3
+DC_IN:
  vias: v1(24.57,124.95) v1(25.1,126.05) v1(27.87,130.79)
+DC_IN_C:
  vias: v1(20.55,125.99) v1(21.67,129.64) v1(23.42,124.28) v4(22.13,127.89) v4(22.1,127.05) v4(22.1,126.18) v4(22.99,126.18) v4(23.88,126.17)
+RTC_CELL_VBAT: length 296.7
  TOP w0.203: v2(26.93,72.26) 26.93,72.32 27.55,72.95 U2401.122
  TOP w0.305: v2(26.93,72.26) 25.12,72.26 24.65,72.73 24.65,73.45 23.09,75.01 R2451.2
  TOP w0.356: v1(177.8,51.56) v2(178.19,51.96)
  L3 w0.508: v2(109.6,38.41) 109.6,38.96 112.04,41.39 v2(127.83,41.39) ; v2(170.16,77.01) 170.16,75.61 170.73,75.04 170.73,74.64 172.38,72.99 172.38,70.78 178.16,65 178.16,62.7 178.76,62.09 178.76,60.84 176.91,58.99 176.91,53.03 177.98,51.96 v2(178.19,51.96)
  L5 w0.508: v2(127.83,41.39) 130.85,38.37 142.9,38.37 144.36,36.91 145.3,36.91 145.68,37.29 148.18,37.29 148.58,36.88 156.77,36.88 157.22,37.33 160.02,37.33 160.72,36.63 165.41,36.63 166.11,37.33 167.95,37.33 169.33,38.7 173.23,38.7 177.63,43.1 177.63,51.39 v2(178.19,51.96) ; v2(26.93,72.26) 24.41,69.75 24.41,68.82 23.04,67.45 23.04,64.76 22.64,64.37 22.07,64.37 21.44,63.74 21.44,63.15 15.27,56.97 15.27,51.26 15.1,51.09 15.1,48.4 14.58,47.87 14.58,43.01 15.19,42.39 15.19,35.74 15.43,35.5 15.43,31.73 18.79,28.37 19.24,28.37 22.52,25.1 30.21,25.1 31.47,26.35 31.47,27.2 35.96,31.69 36.21,31.94 53,31.94 53.87,32.82 55.81,32.82 56.65,31.98 60.82,31.98 61.43,32.59 82.66,32.59 83.44,33.36 97.06,33.36 97.79,32.64 105.02,32.64 108.94,36.56 108.94,37.75 v2(109.6,38.41)
  BOTTOM w0.305: v2(26.93,72.26) 26.93,72.03 26.62,71.73 26.62,71.73 C2428.1 26.22,71.38 R2496.2
  BOTTOM w0.508: R2472.1 R2476.1 163.43,92.36 164.11,91.67 166.8,91.67 167.64,90.83 167.64,81.84 170.31,79.17 170.31,77.17 v2(170.16,77.01)
+RTC_VCC: length 150.2
  TOP w0.508: v2(197.74,37.64) AFTP6615.1 198.71,35.92 198.94,35.92 201.68,33.17 v2(201.68,31.42) ; R2504.1 157.29,94.31 Q2505.G 157.16,94.35 157.11,94.29 157.04,94.29 156.49,93.74 156.49,92.49 156.5,92.48 156.5,92.29 156.72,92.08 158.18,92.08 D2501.2 158.61,92.51 v2(159.41,92.51)
  L3 w0.508: v2(181,69.72) 182.94,67.78 182.94,64.63 185.17,62.41 196.59,62.41 199.13,64.95 209.88,64.95 210.67,65.74 221.43,65.74 222.89,64.29 222.89,62.79 221.88,61.79 221.88,40.96 221.88,38.1 220.71,36.93 218.35,36.93 216.85,35.43 215.31,35.43 214.07,34.2 214.07,33.35 212.13,31.41 209.43,31.41 209.03,31.8 203.86,31.8 203.48,31.42 v2(201.68,31.42)
  L6 w0.508: v2(159.41,92.51) 160.76,92.51 163.89,89.38 163.89,84.07 165.33,82.63 165.33,80.99 168.49,77.83 170.67,77.83 174.45,74.05 174.45,73.74 175.85,72.34 177.86,72.34 179.34,70.86 179.34,70.78 180.4,69.72 v2(181,69.72)
  BOTTOM w0.305: IOBD1.13 197.3,38.09 v2(197.74,37.64)
+SDC_IN: length 28.7
  TOP w0.254: v2(189.74,54.2) 189.8,54.14 194.3,54.14 194.94,54.78 197.3,54.78 198.07,54 R7432.1
  TOP w0.305: 203.13,53.54 202.9,53.77 201.66,53.77 201.45,53.98 EC8971.1 EC8974.1 198.5,53.98 R7432.1
  TOP w0.508: EC8969.1 30.25,125.42
  L3 w0.254: v2(189.74,54.2) 190.17,54.2 190.43,54.46 190.43,56.85 190,57.28 182.5,57.28 181.49,56.26 v2(181.49,55.47)
  vias: v2(31.45,109.4) v4(33.4,126.42) v4(33.4,125.53) v4(34.29,126.42) v4(34.29,125.53) v4(41.23,62.16) v4(41.84,62.74) v4(42.03,61.83) v4(42.68,62.41)
+SDC_IN_SW:
  vias: v1(36.86,128.35)
+SDC_IN_SW_R1: length 18.1
  TOP w0.254: v2(38.2,126.42) 38.15,126.47 R4465.1 ; Q4449.3 27.23,119.74 27.05,119.56 27.05,119.13 v1(27.26,118.93) 27.87,118.93 v2(28.12,119.18)
  L6 w0.254: v2(28.12,119.18) 28.12,119.33 29.85,121.06 30.79,121.06 31.42,120.42 31.44,120.42 31.44,120.42 32.88,120.42 34.28,121.82 35.52,121.82 38.2,124.5 v2(38.2,126.42)
+V_VREF_PATH1:
  vias: v1(73.97,39.14)
+V_VREF_PATH2: length 1.7
  TOP w0.508: R1309.1 C1323.2 145.09,42.75 144.96,42.62 v1(144.91,42.62)
AC_DIS: length 172.5
  TOP w0.089: U2401.69 38.38,61.69 38.29,61.6 37.66,61.6 v2(37.24,62.03) ; v2(27.46,124.41) 27.76,124.11 Q4304.B 27.76,122.9 R4312.1 26.91,122.58 R4481.2 ; v2(25.99,27.26) 25.99,28.33 27.46,29.8 v1(27.46,30.28) 27.85,30.67 27.85,33.97 v2(28.27,34.39)
  L3 w0.089: v2(28.27,34.39) 28.17,34.5 28.17,39.24 28.48,39.55 28.48,40.23 26.52,42.18 26.52,48.91 31.04,53.43 31.04,55.93 36.27,61.16 36.51,61.16 37.24,61.89 v2(37.24,62.03)
  L5 w0.089: v2(27.46,124.41) 27.46,124.24 26.87,123.65 26.87,121.25 27.34,120.77 27.34,116.83 27.96,116.21 27.96,113.76 26.93,112.73 26.93,103.15 28.64,101.44 31.24,101.44 37.09,95.59 37.09,94.16 39.21,92.03 39.21,77.71 37.13,75.63 36.99,75.63 30,75.63 29.42,75.05 29.42,72.93 26.92,70.44 26.92,69.16 23.82,66.06 23.82,63.81 22.6,62.59 22.03,62.59 16.09,56.66 16.09,50.04 16.5,49.62 16.71,49.42 16.71,36.07 17.19,35.58 17.19,32.34 20.6,28.93 20.6,28.66 23.03,26.23 24.76,26.23 25.78,27.26 v2(25.99,27.26)
AC_IN#_G: length 22.2
  TOP w0.254: v1(42.66,118.04) 42.23,118.47 R4377.1 41.71,118.39 U4302.5 v2(39.25,118.39) ; R4376.2 26.96,125.1 27.48,125.1 28.15,124.44 29.34,124.44 29.75,124.03 v2(29.75,123.83)
  BOTTOM w0.254: v2(29.75,123.83) 29.92,123.83 30.36,123.39 30.36,123.09 31.02,122.43 33.05,122.43 33.68,123.06 34.55,123.06 34.55,123.07 35,123.07 35,123.06 38.11,123.06 39.35,121.83 39.35,120.05 39.73,119.67 39.73,118.88 v2(39.25,118.39)
AC_PRESENT: length 78.2
  TOP w0.089: v2(154.18,69.52) 153.83,69.88 153.83,72.9 154.56,73.63 155.76,73.63 156.11,73.28 Q1702.3 156.53,73.4 156.53,73.86 156.77,74.1 EC1707.1 ; D1701.A 145.72,66.71 145.47,66.96 v1(145.14,66.96) 144.92,66.96 143.15,68.73 141.79,68.73 141.38,69.15 v2(141.38,69.52) 141.53,69.67 RN1704.7
  BOTTOM w0.076: 103.43,83.61 103.43,83.97 103.41,84.02 103.41,84.03 103.41,84.33 103.41,84.34 103.43,84.39 103.43,84.62 103.41,84.67 103.17,84.91 CPU1.BU35
  BOTTOM w0.089: 103.43,83.61 104.18,82.87 104.18,81.19 105.32,80.06 105.32,78.87 105.59,78.6 105.59,76.62 111.62,70.59 115.14,70.59 115.14,70.59 115.76,70.59 118.38,67.97 132,67.97 132.24,67.73 139.58,67.73 v2(141.38,69.52) 142.03,68.87 153.53,68.87 v2(154.18,69.52)
ACOK#: length 4
  TOP w0.127: PR4427.2 207.41,41.01 v2(207.41,40.29) v1(208.16,40.37)
  BOTTOM w0.127: PQ4415.3 207.28,40.39 207.38,40.29 v2(207.41,40.29) 207.47,40.29 207.93,40.75 PQ4415.2
ACOK_IN_M: length 504.3
  TOP w0.089: v2(142.93,69.52) 142.93,69.44 v1(144.43,67.95) 144.51,68.03 D1701.K ; v2(209.22,44.81) 209.22,43.33 211.08,41.48 211.5,41.48 211.83,41.15 211.83,40.03 211.17,39.37 208.11,39.37 208.03,39.3 205.13,39.3 204.73,38.89 204.73,36.2 204.09,35.56 v2(204.09,33.45) ; v2(37.49,133.12) 37.29,133.33 D4305.K
  L3 w0.089: v2(178.7,70.6) 179.27,70.6 181.56,68.31 181.56,68.29 182.34,67.51 182.34,64.38 184.92,61.81 196.84,61.81 198.96,63.93 218.31,63.93 221.28,60.96 221.28,40.15 220.04,38.91 219.5,38.91 218.31,37.72 216.88,37.72 216.88,37.72 216.73,37.72 216.34,37.33 216.34,37.33 216.09,37.08 215.99,36.98 215.99,36.97 215.78,36.77 212.67,36.77 212.16,37.28 209.79,37.28 205.55,33.03 204.52,33.03 v2(204.09,33.45)
  L5 w0.089: v2(37.49,133.12) 37.49,132.2 36.08,130.79 32.15,130.79 26.33,124.97 26.33,120.26 26.69,119.9 26.69,115.98 26.95,115.73 26.95,114.06 26.5,113.62 26.5,113.06 26.39,112.95 26.39,102.93 29.98,99.35 29.98,94.35 30.65,93.68 36.31,93.68 38.68,91.31 38.68,77.93 36.93,76.18 29.75,76.18 29.11,75.53 28.43,75.53 26.35,73.45 26.35,72.67 26.08,72.4 25.04,72.4 23.7,71.06 23.7,68.71 23.14,68.15 22.16,68.15 20.34,66.33 20.34,62.73 14.84,57.23 14.84,51.44 14.67,51.27 14.67,48.57 14.15,48.05 14.15,42.71 14.77,42.09 14.77,35.56 15,35.33 15,31.56 21.89,24.67 30.39,24.67 31.89,26.17 31.89,27.02 36.39,31.52 60.95,31.52 61.6,32.16 82.84,32.16 83.45,32.78 92.23,32.78 92.8,32.21 105.2,32.21 109.42,36.44 109.42,37.32 110.07,37.97 110.07,41.58 111.93,43.44 125.17,43.44 130.67,37.94 132.24,37.94 135.38,34.81 136.23,34.81 137.08,35.66 137.62,35.66 138.1,35.17 138.1,35.09 138.41,34.78 147.73,34.78 148.22,34.29 150.37,34.29 150.99,34.91 165.19,34.91 165.19,34.91 166.17,34.91 166.72,35.46 168.52,35.46 169.4,36.34 173.6,36.34 174.96,37.69 185.3,37.69 185.67,37.32 v2(185.67,37.31)
  L6 w0.089: v2(191.65,33.96) 192.15,33.96 192.79,33.33 199.14,33.33 199.77,33.96 203.58,33.96 v2(204.09,33.45)
  BOTTOM w0.089: v2(142.93,69.52) 143.49,70.07 144.76,70.07 145.19,69.64 145.19,69.35 145.47,69.07 152.05,69.07 152.93,69.95 155.53,69.95 158.03,67.45 174.92,67.45 178.07,70.6 v2(178.7,70.6) ; PQ4415.6 208.58,43.48 209.22,44.12 v2(209.22,44.81) ; v2(185.67,37.31) 185.67,37.32 185.67,37.59 185.85,37.77 187.81,37.77 188,37.58 188,36.46 188.19,36.27 190.17,36.27 191.11,35.33 191.11,34.49 v2(191.65,33.96)
AD_IA: length 285.6
  TOP w0.089: v1(23.45,23.85) 23.11,23.51 v2(23.11,22.79) ; v2(36.03,77.76) 35.66,77.4 R2421.1
  L3 w0.089: v2(23.11,22.79) 22.35,22.79 19.13,26.01 16.39,26.01 15.65,26.75 15.65,34.93 16.35,35.63 16.35,38.46 15.24,39.57 15.24,41.84 17.12,43.71 17.12,50.12 17.45,50.45 17.45,58.09 19.54,60.17 19.54,64.32 20.15,64.94 20.15,71.11 21.69,72.65 21.69,74.19 21.7,74.19 21.7,74.24 23.43,75.97 24.68,75.97 24.78,76.07 25.56,76.07 26.19,76.07 26.33,75.93 32.55,75.93 33.26,76.65 34.48,76.65 35.11,77.27 35.54,77.27 v2(36.03,77.76)
  L5 w0.089: v2(23.11,22.79) 23.19,22.79 23.73,22.25 23.73,21.21 25.59,19.35 29.58,19.35 29.88,19.65 31.74,19.65 32.95,20.86 33.06,20.86 33.37,20.86 34.49,21.97 34.49,22.35 40.34,28.2 45.6,28.2 46.08,28.68 89.64,28.68 91.14,30.18 94.44,30.18 95.1,29.52 106.1,29.52 111.49,34.91 111.49,36.89 111.87,37.27 111.87,40.89 112.66,41.68 124.15,41.68 127.49,38.33 127.49,37.37 129.76,35.1 129.76,35.09 130.01,34.84 130.77,34.84 132.85,32.77 v2(134.22,32.77) ; v2(139.22,35.21) 139.68,35.66 141.76,35.66 142.17,35.26 147.51,35.26 148.3,34.47 150.25,34.47 150.86,35.09 165.26,35.09 166.1,35.08 166.87,35.86 168.56,35.86 169.94,37.24 174.25,37.24 174.89,37.87 175.03,37.87 186.87,37.87 188.23,39.23 188.23,39.77 188.23,40.63 189.59,41.99 191.47,41.99 191.9,41.56 192.05,41.56 193.58,41.56 194.69,40.44 196.88,40.44 197.97,41.53 201.23,41.53 v2(202.48,42.79)
  L6 w0.089: v2(139.22,35.21) 138.74,34.72 137.57,34.72 135.61,32.77 v2(134.22,32.77)
  BOTTOM w0.089: PR4412.1 202.59,43.54 PC4432.1 202.47,42.8 v2(202.48,42.79)
AD_OFF_L: length 3
  TOP w0.089: Q4304.C 28.15,125.29 Q4305.1
AD_OFF_R: length 6.1
  TOP w0.254: Q4305.3 26.87,127.65 C4301.2 28.05,128.36 R4307.2 28.44,128.35 R4308.1 29.23,127.85 PU4301.4
ALERT#: length 2.5
  TOP w0.089: v1(125.76,112.91) 125.76,113.54 R2603.2 125.86,114.05 125.37,114.05 124.88,114.54
ALWON: length 10
  TOP w0.089: v2(28.01,69.26) 27.97,69.29 27.97,71.72 27.53,72.16 27.53,72.53 27.95,72.95 U2401.121
  BOTTOM w0.089: v1(23.47,68.65) 23.62,68.51 R4009.2 24.38,68.49 25.98,68.49 26.62,69.13 27.89,69.13 v2(28.01,69.26)
AMBER_LED_BAT: length 33.9
  TOP w0.254: v1(9.66,110.14) v2(9.66,109.58)
  L5 w0.254: v2(9.66,109.58) 9.66,111.56 11.18,113.08 11.18,117.78 13.13,119.74 14.97,119.74 15.98,120.75 16.54,120.75 17.05,121.26 17.05,126.61 14.9,128.75 11.89,128.75 11.51,129.13 v2(9.25,129.13)
  BOTTOM w0.254: Q6403.C 9.78,109.83 9.66,109.7 v2(9.66,109.58) ; v2(9.25,129.13) EC6402.1 10.72,129.19 R6407.1
AON_CT_2: length 2.6
  BOTTOM w0.127: C8605.1 161.8,109.68 v1(162.36,109.12) 162.51,108.97 U8601.10
AUD_AGND: length 19.8
  TOP w0.203: v2(30.05,11.28) 29.9,11.43 29.9,11.71 29.64,11.97 HDA27.31 ; HDA27.19 23.28,12.37 v2(23.17,12.26)
  TOP w0.254: v2(23.17,12.26) 23.11,12.32 C2706.2
  TOP w0.305: v2(34.37,7.37) 34.34,7.39 R2704.1 ; EC2703.1 33.79,6.07 v2(33.79,6.1) ; EC2907.2 19.61,10.54 19.46,10.69 19.46,10.83 v2(19.48,10.85) 19.83,11.2 C2707.2 ; v2(29.87,5.13) 30.48,5.13 EC2701.1 ; R2705.1 v2(31.93,5.06) ; C2702.1 v2(23.65,7.49) 23.65,6.45 23.12,5.92 23.12,4.85 EC2702.1
  TOP w0.356: v2(34.37,7.37) v1(34.31,6.73)
  TOP w0.508: C2710.2 C2711.2 34.09,9.15 v2(34.34,8.89) ; EC2908.2 v2(17.91,8.74) ; C2715.2 17.78,13.26 v2(17.78,12.45)
  L5 w0.508: 6.41,10.35 HPMIC1.MS ; HPMIC1.MS 9.01,10.35 ; HPMIC1.MS 7.71,9.11
  vias: v2(18.87,16.86) v2(20.58,19.1) v2(21.29,10.36)
AUD_HP1_JACK_L: length 3.5
  TOP w0.203: HDA27.25 26.73,10.14
  TOP w0.305: R2922.2 R2913.2 26.39,9.53 R2908.1 26.34,9.75 26.73,10.14
AUD_HP1_JACK_L1: length 7
  TOP w0.305: v2(20.48,9.32) 20.48,10.16 EC2907.1 21.06,9.68 R2907.1 ; v2(24.77,9.32) 25.02,9.58 R2908.2
  L3 w0.305: v2(24.77,9.32) 24.72,9.37 20.53,9.37 v2(20.48,9.32)
AUD_HP1_JACK_R: length 4.3
  TOP w0.203: HDA27.26 27.13,10.44 v1(27.23,10.32)
  TOP w0.305: R2910.1 R2912.2 27.99,8.31 R2921.2 v1(27.23,10.32)
AUD_HP1_JACK_R1: length 14.9
  TOP w0.305: R2910.2 27.53,7.01 v1(27.53,6.37) 27.53,5.89 v2(27.31,5.67) ; R2909.1 18.67,10.29 EC2908.1 17.91,10.69 v2(17.76,10.85)
  L3 w0.305: v2(27.31,5.67) 26.83,5.67 23.85,8.64 19.99,8.64 17.78,10.85 v2(17.76,10.85)
AUD_HPJD_N: length 6
  TOP w0.203: 23.93,15.95 23.93,15.37 24.13,15.17 HDA27.12
  TOP w0.254: 23.93,15.95 v1(23.74,16.15) 23.69,16.15 22.56,17.27 22.56,17.36 21.54,18.38 R2711.2 R2710.2
AUD_PC_BEEP: length 3.7
  TOP w0.127: HDA27.11 24.44,15.95 24.1,16.29 24.1,16.3 23.89,16.51 23.88,16.51 23.04,17.35 C2735.2 23.04,18.09 23.3,18.34 v1(23.3,18.58)
AUD_PC_BEEP_C: length 3.3
  TOP w0.127: D2703.3 22.89,20.37 23.19,20.07 v1(23.19,19.8) 23.19,19.51 22.76,19.08 R2735.1 22.3,18.34 C2735.1
AUD_PORTA_L_HPMIC1: length 17.5
  TOP w0.305: v1(22.56,5.58) 22.56,6.2 v2(22.91,6.55) 22.26,7.2 ED2910.1 21.51,8.54 R2907.2
  L3 w0.305: v2(22.91,6.55) 22.08,7.39 16.61,7.39 14.92,9.08 12.52,9.08 11.81,9.79 HPMIC1.1
AUD_PORTA_R_HPMIC1: length 34
  TOP w0.305: R2909.2 19.46,9.45 v1(19.59,9.32) 19.59,9.32 ED2910.2 20.36,8.15 20.24,8.03 v2(19.54,8.03)
  L3 w0.305: HPMIC1.2 7.87,21.46 17.91,21.46 18.57,20.8 18.57,19.89 14.62,15.93 14.62,11.12 16.34,9.4 18.01,9.4 19.38,8.03 v2(19.54,8.03)
AUD_RING: length 7.7
  L3 w1.016: v4(16.84,12.55) 16.84,13.39 17.48,14.02 22.63,14.02 23.22,14.61
  vias: v1(22.6,16.61) v4(23.14,15.65)
AUD_SENSE: length 4.8
  TOP w0.254: R2923.2 v1(18.34,15.65) 18.82,16.13 18.86,16.13 19.38,16.66 19.38,16.95 19.74,17.31 C2902.1 19.97,17.68 R2711.1
AUD_SLEEVE: length 4.3
  L3 w1.016: v4(22.05,15.6) 21.69,15.95 18.52,15.95 v4(18.09,16.38)
  vias: v1(23.43,14.43)
AUD_SPK_L+: length 16.8
  TOP w0.203: HDA27.35 29.97,13.57 30.74,12.8 v4(31.35,12.8)
  BOTTOM w1.016: 29.87,12.29 29.8,12.29 29.01,11.51 25.52,11.51 22.63,8.62 22.63,7.7 20.35,5.42 20.35,4.9 19.84,4.4 v4(19.84,3.99)
  vias: v1(18.21,3.74)
AUD_SPK_L+_C: length 8
  TOP w1.016: v4(9.07,4.42) 9.07,5.21 AFTP2902.1 12.18,5.89 13.65,4.42 15.37,4.42
AUD_SPK_L-: length 17.1
  TOP w0.203: v4(30.59,13.77) 30.4,13.97 HDA27.36
  BOTTOM w1.016: v4(19.08,5.44) 19.08,5.94 21.36,8.23 21.36,9.15 25,12.78 28.48,12.78 29.47,13.77 v4(30.59,13.77)
  vias: v1(19.73,5.52)
AUD_SPK_L-_C: length 10.2
  TOP w1.016: 15.4,5.72 14.15,5.72 12.7,7.16 9.23,7.16 8.48,6.42 7.8,5.74 AFTP2901.1 v4(7.8,4.37)
AUD_SPK_R+: length 25.5
  TOP w0.203: v4(30.36,14.98) 29.86,14.77 HDA27.38
  BOTTOM w1.016: 31.83,15.65 33.18,15.65 34.01,14.81 34.01,11.34 29.25,6.57 26.05,6.57 21.21,1.73 v4(19.46,1.73)
  vias: v1(20.11,1.65)
AUD_SPK_R+_C: length 4.3
  TOP w1.016: 15.07,1.88 12.5,1.88 AFTP2904.1 v4(11.28,3.1)
AUD_SPK_R-: length 19.8
  TOP w0.203: v4(31.58,14.4) 31.54,14.37 HDA27.37
  BOTTOM w1.016: 32.74,13.88 32.74,11.86 28.73,7.85 25.53,7.85 v4(20.79,3.11)
  vias: v1(20.81,3.77)
AUD_SPK_R-_C: length 5.5
  TOP w1.016: v4(10.37,4.37) AFTP2903.1 11.9,4.37 13.12,3.15 15.34,3.15
AUD_VREF: length 3.4
  TOP w0.203: HDA27.22 25.53,10.92 25.37,10.76 25.33,10.76
  TOP w0.254: 25.33,10.76 25.3,10.72 24.59,10.72 23.65,9.78 C2702.2
AUX_EN_WOWL: length 59.4
  TOP w0.089: v2(102.6,87.78) 102.2,87.38 102.2,86.74 102.31,86.63 102.31,85.91 101.65,85.26 101.65,75.06 102.81,73.9 102.81,72.37 101.76,71.32 66.69,71.32 63.34,74.68 v1(63.07,74.68) R1718.2
  BOTTOM w0.089: v2(102.6,87.78) 102.23,88.15 CPU1.BT30
AUX_EN_WOWL_R: length 112.5
  TOP w0.089: R1718.1 61.17,74.86 v2(60.2,74.86) ; v2(60.74,97.84) 60.63,97.95 60.63,101.63 54.36,107.9 50.16,107.9 Q6102.S ; R2409.2 17.15,58.17 14.59,60.72 v2(14.59,63.88)
  BOTTOM w0.089: v2(60.74,97.84) 59.85,96.95 v1(59.52,96.95) 59.09,96.95 58.41,96.27 57.24,96.27 53.32,92.35 53.32,91.52 54.28,90.55 54.28,88.19 54.26,88.17 53.67,87.58 53.67,78.61 55.06,77.22 60.06,77.22 60.37,76.92 60.37,75.03 v2(60.2,74.86) 59.77,75.29 54.28,75.29 53.09,74.09 51.44,74.09 51.15,73.81 49.44,73.81 49.24,74.01 47.12,74.01 46.71,73.6 37.31,73.6 36.9,73.2 35.43,73.2 34.59,72.35 32.94,72.35 31.96,71.37 31.96,69.94 31.11,69.09 30.52,69.09 30.26,68.83 30.26,68.81 28.85,67.39 25.16,67.39 24.58,66.81 22.51,66.81 22.18,67.13 20.21,67.13 19.63,66.55 18.29,66.55 17.4,65.65 15.54,65.65 14.58,64.7 14.58,63.89 v2(14.59,63.88)
AUX_ON: length 4
  TOP w0.089: U2401.3 22.57,71.69 22.08,72.19 21.44,72.19 v1(21.09,71.83) 20.96,71.71 R2466.2
BAT1_LED#: length 20.1
  TOP w0.089: v2(33.28,75) 33.45,75 33.83,74.62 33.83,74.61 33.95,74.48 U2401.106 ; v2(22.79,73.08) 22.36,72.65 RN2405.1
  L3 w0.089: v2(33.28,75) 33.1,75 32.77,74.67 31.43,74.67 30.34,75.76 26.25,75.76 26.11,75.9 24.86,75.9 24.75,75.79 23.9,75.79 v2(22.36,74.25)
  L5 w0.089: v2(22.36,74.25) 22.36,73.58 22.79,73.15 v2(22.79,73.08)
  BOTTOM w0.089: v2(22.36,74.25) 22.36,75.5 22.48,75.63 Q2416.4 22.92,76.31 23.19,76.58 R2452.1 ; v1(22.23,72.9) v2(22.79,73.08)
BAT2_LED#: length 6.1
  TOP w0.203: U2401.1 23.73,72.89 v2(23.97,73.12)
  TOP w0.254: v2(23.97,73.12) 23.33,73.76 22.51,73.76 RN2405.2 v1(21.75,74.11)
  BOTTOM w0.254: v2(23.97,73.12) 23.97,73.14 24.22,73.4 Q2416.1 24.24,73.99 R2453.2
BAT_AMBER: length 11.7
  L6 w0.254: v2(2.11,131.93) 2.51,131.93 2.84,131.6 9.55,131.6 v2(10.54,130.61)
  BOTTOM w0.254: v2(2.11,131.93) 2.7,132.52 LED1.1 ; v2(10.54,130.61) 10.9,130.61 R6407.2
BAT_WHITE: length 16.1
  L6 w0.254: v2(12.98,129.97) 12.86,130.1 10.33,130.1 9.34,131.09 2.63,131.09 v2(2.37,131.35)
  BOTTOM w0.254: v2(2.37,131.35) 3.7,132.68 3.7,133.92 3.35,134.27 LED1.2 ; R6406.2 12.32,129.97 v2(12.98,129.97)
BATT_WHITE_LED#: length 79.3
  L5 w0.089: v2(13.98,26.31) 13.98,34.85 13.72,35.1 13.72,37.75 10.9,40.57 10.9,46.05 13.85,49 13.85,51.66 13.97,51.79 13.97,57.61 16.54,60.17 16.54,63.19 17.96,64.62 17.96,67.49 19.85,69.37 19.85,73.79 23.63,77.57 24.15,77.57 24.49,77.24 24.49,77.06 24.47,77.03 v2(24.47,77.03)
  BOTTOM w0.089: Q6401.D 20.7,35.86 20.7,31.61 19.9,30.81 19.23,30.81 17.94,29.52 15.9,29.52 15.04,28.65 15.04,27.33 14.02,26.32 13.98,26.32 v2(13.98,26.31) ; Q6406.4 25.76,77.09 R6409.2 25.2,76.33 v1(24.9,76.63) 24.86,76.63 v2(24.47,77.03) 24.22,76.79 Q2416.6 24.22,75.14 24.51,74.86 R2453.1
BATT_WHITE_LED#_Q: length 72.3
  L3 w0.089: v2(15.62,110.31) 16.54,110.31 16.89,109.96 19.94,109.96 20.58,109.32 25.76,109.32 26.27,108.81 26.27,102.49 27.02,101.73 27.02,97.31 27.18,97.15 27.18,94.87 27.57,94.48 27.57,93.63 27.82,93.38 28.17,93.38 30.22,91.33 38.46,91.33 38.54,91.26 38.54,77.93 36.98,76.37 35.48,76.37 34.8,75.69 33.91,75.69 33.74,75.52 33.74,74.68 33.51,74.46 31.32,74.46 30.2,75.58 25.54,75.58 v2(25.43,75.46)
  BOTTOM w0.089: v2(25.43,75.46) 25.76,75.46 R6409.1 27.1,76.33 27.44,76.67 v1(27.48,76.67) 27.48,77.02 Q6406.3 ; Q6404.B 15.62,110.58 v2(15.62,110.31)
BEEP: length 62.4
  TOP w0.127: v2(27.61,62.33) 27.67,62.33 29.96,60.04 U2401.45 ; v2(24.61,26.77) 24.54,26.77 v1(24.01,26.24) 23.4,25.63 R2739.1
  L5 w0.127: v2(28.27,33.73) 28.1,33.73 26.42,32.06 21.79,32.06 20.9,32.95 20.9,46.73 21.69,47.52 21.69,50.57 22.11,50.99 22.11,52.38 23.08,53.35 23.08,56.17 23.34,56.43 23.39,56.43 24.65,57.68 24.89,57.68 25.29,58.09 25.91,58.09 27.05,59.23 27.66,59.23 28.03,59.61 28.03,61.88 27.61,62.3 v2(27.61,62.33)
  L6 w0.127: v2(24.61,26.77) 24.34,26.77 24.24,26.87 24.24,27.44 23.98,27.7 23.38,27.7 22.52,28.56 22.52,32.32 23.96,33.76 25.02,33.76 25.67,34.41 27.6,34.41 v2(28.27,33.73)
BKLT_CTRL: length 29.6
  TOP w0.089: v2(224.41,39.51) 223.94,39.04 222.63,39.04 222.5,38.91 RN5503.3 222.5,38.15 222.63,38.03 RN5502.2 ; v2(209.79,48.49) v1(209.4,48.89)
  L6 w0.089: v2(224.41,39.51) 223.52,38.62 223.52,37.71 221.46,35.64 219.43,35.64 216.8,38.28 215.71,38.28 211.81,42.17 211.81,44.76 209.76,46.81 209.76,48.46 v2(209.79,48.49)
  BOTTOM w0.089: v2(209.79,48.49) 210.15,48.49 D5503.3
BKLT_IN_EC: length 7.3
  TOP w0.089: R2435.1 40.49,56.26 v1(40.49,56.74) 41.23,57.48 41.23,60.12 40.61,60.74 40.47,60.74 40.32,60.89 U2401.67
BLON_OUT_C: length 5.9
  TOP w0.089: v2(220.24,41.37) 220.29,41.37 220.92,40.74 222.11,40.74 v1(222.26,40.6) 223.09,39.76 RN5503.5
  BOTTOM w0.089: LCD1.30 219.28,42.55 219.64,42.19 219.89,42.19 220.25,41.84 220.25,41.38 v2(220.24,41.37)
BLUETOOTH_EN: length 245.4
  TOP w0.089: v2(32.79,35.92) 33.77,35.92 35.62,37.77 35.62,38.16 36.78,39.31 36.78,41.27 37.3,41.8 41.61,41.8 42.3,42.49 45.86,42.49 46.33,42.95 46.36,42.95 47.81,44.4 47.81,49 47.83,49.03 47.83,49.82 55.3,57.29 98.77,57.29 99.03,57.04 108.41,57.04 118.23,66.85 118.23,69.96 118.05,70.14 118.05,77.08 123.5,82.53 123.5,89.1 121.41,91.19 121.41,92.73 120.87,93.27 120.53,93.27 117.83,95.97 v2(117.83,96.4) ; v2(42.44,106.23) 42.44,105.48 R6108.2 42.61,105.15 42.36,104.9 42.31,104.9 41.23,103.81 AFTP6112.1
  L5 w0.089: v2(42.44,106.23) 41.18,104.97 41.18,80.06 41.83,79.41 41.83,77.58 41.14,76.88 40.07,75.82 40.07,73.74 38.14,71.81 37.74,71.81 36.7,70.77 36.7,69.63 36.41,69.34 32.85,69.34 32.14,68.63 32.14,67.84 30.39,66.09 30.39,61.13 26.27,57.01 26.27,56.71 25.69,56.13 25.43,56.13 23.67,54.36 23.67,53.1 22.74,52.17 22.74,50.63 22.33,50.22 22.33,47.24 21.68,46.59 21.49,46.4 21.49,33.27 22.11,32.65 26.11,32.65 27.33,33.86 27.33,34.35 27.33,34.35 27.33,34.64 27.99,35.3 32.38,35.3 32.79,35.71 v2(32.79,35.92)
  BOTTOM w0.089: CPU1.CP14 113.17,98.08 114.82,98.08 114.9,98.16 116.71,98.16 117.34,97.53 117.34,97.47 117.83,96.97 v2(117.83,96.4)
BLUETOOTH_EN_R: length 4
  TOP w0.089: v2(44.15,103.54) 44.25,103.64 v1(44.25,104.09) 44.25,104.21 44.02,104.45 R6115.2 43.38,104.44 R6108.1
  BOTTOM w0.089: v2(44.15,103.54) 44.2,103.59 WLAN1.54
BMON22: length 272.8
  TOP w0.254: PR4493.2 195.56,45.72 192.76,45.72 v1(192.28,45.24) 189.6,45.24 187.5,43.14 186.37,43.14 v2(186.13,43.37) ; R2483.1 v2(31.5,77.78) ; v2(146.18,36.65) 146.18,35.89 143.23,32.95 135.28,32.95 134.9,33.33 132.64,33.33 130.7,35.27 v2(130.19,35.27)
  L3 w0.254: v2(31.5,77.78) 30.94,77.22 30.15,77.22 29.67,77.7 23.59,77.7 18.06,72.17 18.06,65.79 19.23,64.62 19.23,60.68 16.36,57.81 16.36,49.96 16.77,49.56 16.77,43.83 14.86,41.92 14.86,39.36 15.33,38.89 15.33,26.57 16.27,25.63 18.82,25.63 v2(20.6,23.85)
  L5 w0.254: v2(146.18,36.65) 146.48,36.35 157.13,36.35 157.6,36.82 159.69,36.82 160.47,36.04 165.66,36.04 166.44,36.82 168.17,36.82 169.54,38.2 173.83,38.2 178.82,43.19 185.94,43.19 v2(186.13,43.37) ; v2(20.6,23.85) 21.15,23.3 23.6,23.3 25.87,21.03 32.21,21.03 32.59,21.41 33.14,21.41 33.94,22.2 33.94,24.11 36.02,26.19 36.02,27.56 37.85,29.39 89.37,29.39 90.73,30.75 106.91,30.75 111.13,34.97 111.13,36.95 111.57,37.4 111.57,41.01 112.53,41.97 124.27,41.97 127.82,38.43 127.82,37.64 v2(130.19,35.27)
BOARD_ID: length 5.6
  TOP w0.089: U2401.111 31.95,74.68 32.19,74.91 32.19,75.21 32.18,75.22 32.18,76.38 32.38,76.57 v1(32.38,76.58) 32.93,76.58 C2408.1 34.04,76.18 R2444.1 34.8,76.23 R2443.2
BOARD_ID1: length 17
  L3 w0.089: v2(108.51,99.01) 108.94,98.59 112.07,98.59 112.72,99.24 114.38,99.24 114.52,99.09 119.55,99.09 119.61,99.15 120.95,99.15 v2(121.54,98.56)
  BOTTOM w0.089: R2010.2 R2009.1 122.43,98.55 v1(122.28,98.4) 121.7,98.4 v2(121.54,98.56) ; v2(108.51,99.01) 108.51,99.05 CPU1.CG12
