# Allegro board 17931-1.1228WZS1336.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
3V_5V_POK#: length 3.8
  TOP w0.089: R1726.1 158.63,69.37 158.39,69.61 Q1701.6 ; R1726.1 v1(158.98,68.07) ; R1726.1 158.4,68.96 157.74,69.62 Q1701.5
5V_3V_TPAN_PWR:
  vias: v1(155.76,107.37)
5V_FAN_VCC: length 7.3
  TOP w0.508: D2601.K 163.22,86.45 C2604.1 163.22,87.96 162.49,88.7 AFTP2603.1 v2(160.07,88.7)
  BOTTOM w0.508: v2(160.07,88.7) 160.07,88.7 FAN1.1
5V_HDD_S0:
  vias: v1(159.82,38.84) v2(159.85,39.78) v2(160.57,39.78) v2(161.32,39.78)
5V_HDMI: length 8.7
  TOP w0.508: F5701.2 16.82,101.4 C5736.2 16.8,102.07 15.49,102.07 v2(14.96,102.59)
  BOTTOM w0.508: U5702.2 15.28,102.91 v2(14.96,102.59) ; v2(14.96,102.59) 15.04,102.52 v1(15.04,101.93) ; v2(14.96,102.59) 14.71,102.59 13.95,103.35 HDMI1.18
5V_IRLED: length 10.8
  TOP w0.254: v2(220.22,45.62) 220.14,45.62 219.71,45.19 219.71,44.81 219.54,44.63 219.54,44.46 218.98,43.89 C5504.1 AFTP5512.1 219.23,42.01 219.48,42.27 220.09,42.27 220.75,41.61 220.75,41.53 221.17,41.12 223.27,41.12 F5506.2
  BOTTOM w0.305: LCD1.24 220.15,45.55 v2(220.22,45.62)
5V_ODD_S0:
  vias: v2(185.63,34.25) v2(190.43,34.06)
5V_S0: length 468.1
  TOP w0.305: v4(82.48,38.58) 82.47,38.59 EC8935.1 81.08,37.81 FC8916.1 ; v2(224.41,40.16) 224.41,40.66 224.61,40.87 F5506.1 ; FC8903.1 20.87,93.22 Q5701.G ; v2(19.13,11.38) 19.1,11.38 18.88,11.15 R2703.2 ; v2(195.66,65) 195.79,64.87 FC8902.1
  TOP w0.508: R7014.1 139.46,91.3 139.6,91.16 139.6,90.22 139.27,89.89 139.09,89.71 v2(138.81,89.71) ; PR8551.1 148.83,81.36 v2(150.37,79.82) ; v2(205.44,60.48) 205.26,60.3 EC8936.1 ; D5701.3 18.7,92.28 v4(19.36,92.94) ; v2(17.1,100.24) F5701.1 17.1,98.86 18.27,97.69 18.27,97.6 18.82,97.04 18.82,97.04 18.92,96.94 18.92,93.37 v4(19.36,92.94) ; R2612.1 159.54,89.41 v2(160.07,89.41) 162.95,89.41 164.11,88.24 164.11,87.02 165.26,85.88 R5502.1 165.59,85.78 FC8915.1 v1(167.72,84.86) 167.72,83.92 168.1,83.54 168.1,81.81 177.11,72.8 179.96,71.62 182.21,70.69 182.26,70.58 v2(183.35,70.13) ; v4(19.36,92.94) 20.57,92.94 Q5701.G ; v2(202.85,41.15) 202.85,39.85 204.19,38.51 EC6601.1 204.19,36.55 203.33,35.69 v2(203.33,32.82)
  L5 w0.305: v2(202.85,41.15) 204.32,41.15 206.07,42.9 208.07,42.9 210.37,45.2 210.37,45.65 211.83,47.11 v2(211.83,47.97)
  L5 w0.508: v2(150.37,79.82) 149.26,79.82 147.88,78.43 144.42,78.43 143.44,77.45 140.32,77.45 136.78,80.99 136.78,87.68 v2(138.81,89.71) ; v4(61.34,37.03) 60.57,36.26 56.07,36.26 54.82,37.52 54.82,38.17 51.51,41.48 39.93,41.48 36.77,38.32 36.77,37.54 34.55,35.32 34.47,35.32 31.53,32.39 27.68,32.39 26.69,31.4 21.45,31.4 20.17,32.67 20.17,35.99 18.91,37.25 18.91,49.16 19.87,50.12 19.87,55.15 23.34,58.62 24.5,58.62 26.34,60.47 26.34,64.31 28.17,66.14 28.17,67.21 30.52,69.56 v2(30.52,69.94) ; v2(224.41,40.16) 222.23,40.16 221.6,40.79 221.6,53.07 222.46,53.93 222.46,59.83 219.26,63.02 219.17,63.02 218.72,63.47 217.6,63.47 217.15,63.02 v2(217.15,62.84)
  L6 w0.381: v2(19.13,11.38) 19.03,11.38 18.77,11.13 18.77,7.14 20.42,5.49 20.42,4.93 21.34,4.01 23.63,4.01 24.09,4.48 34.31,4.48 35.8,5.98 35.8,12.1 34.55,13.36 v4(34.55,18.81)
  L6 w0.508: v2(101.6,39.4) 100.66,38.46 91.44,38.46 90.86,37.87 83.19,37.87 v4(82.48,38.58) ; v2(195.66,65) 195.66,65.63 195.05,66.24 189.8,66.24 187.54,68.5 186.62,68.87 185.55,69.24 183.97,69.24 183.53,69.69 v2(183.35,70.13) ; v2(224.41,40.16) 224.67,40.16 225.4,39.43 225.4,37.19 222.82,34.6 218.29,34.6 217.46,35.43 215.29,35.43 213.82,33.96 213.82,33.1 212.41,31.69 211.33,31.41 208.22,31.41 ; v2(160.07,89.41) 159.82,89.41 159.41,89 159.41,84.66 155.43,80.67 150.78,80.67 150.37,80.27 v2(150.37,79.82) ; v2(205.44,60.48) 206.1,61.14 215.84,61.14 217.15,62.45 v2(217.15,62.84)
  L6 w0.762: v3(33.4,27.23) 33.4,27.37 36.15,30.11 38.6,30.11 40.46,31.97 52.74,31.97 55.32,34.56 60.09,34.56 61.32,35.79
  BOTTOM w0.203: ED5502.5 212.77,47.97 v2(211.83,47.97)
  BOTTOM w0.305: Q6505.E 101.33,39.67 v2(101.6,39.4)
  BOTTOM w0.508: ED6601.5 203.71,41.15 v2(202.85,41.15) ; v4(19.36,92.94) 21.14,92.94 21.72,92.36 25.17,92.36 25.64,92.82 37.79,92.82 39.21,91.4 v1(43.16,91.4) 51.87,91.4 53.48,89.79 53.48,88.49 52.86,87.87 52.86,78.33 52.53,78 51.39,78 50.94,77.55 50.94,76.96 48.8,74.83 43.66,74.83 43.43,75.06 43.07,75.06 38.6,75.06 38.06,74.52 37.19,74.52 36.95,74.28 36.56,73.89 35.25,73.89 34.76,73.4 34.74,73.4 34.69,73.35 32.22,73.35 30.58,71.71 30.58,70 v2(30.52,69.94) ; v2(17.1,100.24) 17.1,100.76 18.29,101.96 U5702.3
  BOTTOM w0.762: F6501.1 82.24,37.46 82.48,37.69 v4(82.48,38.58)
  vias: v1(35.44,18.95) v1(63.12,36.12) v1(155.73,34.82) v1(190.45,31.62) v2(155.16,33.81) v2(155.81,33.81) v2(156.44,33.81) v2(157.08,33.81) v3(190.45,32.49) v4(34.55,19.65) v4(62.18,37.03) v4(63.02,37.03)
5V_S5: length 349.8
  TOP w0.203: U4001.4 48.02,132.48 48.09,132.41 v2(48.8,132.41)
  TOP w0.254: v3(20.14,121.59) 20.2,121.54 FC8917.1 ; v2(16.89,51.11) 17.37,51.11 R3606.1 R3602.1 ; 49.8,40.91 45.91,40.91 44.65,39.65 PG4527.2 ; v3(20.2,122.28) 20.22,122.3 EC8949.1
  TOP w0.305: v2(113.76,112.4) 113.69,112.4 113.16,112.92 113.16,113.59 111.53,115.22 C4031.1 110.95,116.08 111.44,116.57 U4006.3 ; EC8947.1 16.56,89.56 v4(16.21,89.21) ; EC8948.1 v2(18.29,98.78) 18.29,99.39 R4303.1 ; R3605.1 17.65,54.92 17.32,54.92 v2(17,54.92)
  TOP w0.406: v2(94.75,72.57) 95.51,72.57 C4041.1 96.04,72.77 96.43,73.16 U4003.3 ; v2(108.58,119.76) 108.58,119.77 108.48,119.87 C4032.1 108.48,120.63 108.24,120.87 U4002.3
  TOP w0.508: PR4803.2 79.61,136.42 v2(80.44,136.42) 80.57,136.3 PC4877.1 81.11,135.61 81.59,136.09 82.91,136.09 84.92,138.1 87.25,138.1 90.5,141.35 PR4670.2 v2(90.5,145.47) ; v2(63.47,135.94) PC4766.1 64.27,137.03 67.31,140.07 v2(67.31,141.4) 68.1,141.4 68.41,141.71 75.37,141.71 75.77,141.3 75.77,139.8 75.3,139.33 74.74,139.33 ; v2(115.24,112.9) 121.27,112.9 121.9,112.27 v2(123.62,112.27) ; v2(108.69,135.36) 109.02,135.03 109.02,132.01 116.02,125.01 117.67,125.01 v2(119.28,123.39)
  L3 w0.508: v2(113.76,112.4) 113.71,112.45 113.49,112.45 113.12,112.82 113.12,113.35 113.13,113.35 113.13,114.25 108.53,118.85 108.53,119.72 v2(108.58,119.76)
  L5 w0.508: 167.21,109.37 167.21,108.43 166.78,108 166.78,107.75 165.36,106.33 162.46,106.33 159.01,102.87 v2(158.45,102.87) ; 167.21,109.37 v2(166.53,109.37) ; 167.21,109.37 167.21,110.52 166.45,111.28 163.15,111.28 162.44,111.99 159.21,111.99 158.78,112.42 152.61,112.42 152.35,112.17 146.99,112.17 145.54,110.71 139.36,110.71 135.33,114.73 133.2,114.73 130.33,117.6 v2(129.7,117.6) ; v2(115.24,112.9) 114.73,112.4 v2(113.76,112.4)
  L6 w0.254: v2(100,44.45) 99.42,45.04 99.42,46.44 99.43,46.45 99.43,48.6 91.32,56.72 91.32,63.68 95.38,67.74 95.38,72.32 95.13,72.57 v2(94.75,72.57)
  L6 w0.305: v2(48.8,132.41) 49.24,132.41 49.73,131.93 50.08,131.93 50.63,131.38 50.63,130.86 51.69,129.8 ; v2(195.63,55.47) 195.63,55.36 196.23,54.76 197.89,54.76 199.14,53.52 204.55,53.52 207.14,50.93 207.14,50.17 206.34,49.37 206.33,49.37 206.24,49.28 206.09,49.28 205.87,49.06 205.87,48.92 205.67,48.72 205.67,45.16 206.08,44.75 208.11,44.75 208.77,44.1 208.77,43.6 208,42.83 206.24,42.83 204,40.59 201.6,40.59 201.24,40.95 198.56,40.95 196.6,38.99 196.6,37.44 v2(194.69,35.54)
  L6 w0.508: v2(99.7,138.74) 99.43,138.09 99.32,137.97 ; v2(74.13,136.75) 74.74,137.36 79.51,137.36 v2(80.44,136.42) ; 83.25,150.69 83.25,151.07 80.83,153.49 v2(80.83,155.12) ; v2(108.69,135.36) 106.63,135.36 104.98,137.01 100.28,137.01 99.32,137.97 ; v3(44.25,123.62) 45.17,124.54 45.17,125.25 48.8,128.87 50.77,128.87 53.34,131.45 53.34,131.8 56.78,135.24 62.76,135.24 v2(63.47,135.94) ; 99.32,137.97 97.57,137.97 90.76,144.78 90.66,144.78 90.5,144.93 v2(90.5,145.47) 89.69,146.28 89.69,147.13 88.68,148.14 86.61,148.14 86.26,148.49
  BOTTOM w0.203: U8601.4 v2(166.53,109.37)
  BOTTOM w0.254: v2(98.48,39.6) 98.48,42.93 v2(100,44.45)
  BOTTOM w0.305: Q6405.E 195.63,54.99 v2(195.63,55.47) ; v2(63.47,135.94) 63.76,135.94 63.8,135.9 PU4701.29 ; PR4610.1 77.7,155.04 78.06,155.4 80.55,155.4 v2(80.83,155.12) ; PU4802.29 74.47,135.96 74.13,136.29 v2(74.13,136.75) ; PU4801.29 80.76,136.01 80.44,136.32 v2(80.44,136.42) ; v2(11.69,108.43) 14.42,108.43 Q6404.E
  BOTTOM w0.508: 124.89,116.94 125.43,117.48 128.63,117.48 128.76,117.6 v2(129.7,117.6) ; 124.89,116.94 124.69,116.73 124.69,113.61 123.62,112.55 v2(123.62,112.27) ; 124.89,116.94 121.49,120.35 v1(121.31,120.35) 119.13,122.53 119.13,123.24 v2(119.28,123.39) ; 154.87,103.56 154.87,103.1 155.72,102.25 157.39,102.25 158.02,102.87 v2(158.45,102.87) ; v2(11.69,108.43) 11.69,109.24 Q6403.E ; PR4704.2 67.34,141.38 v2(67.31,141.4) ; PU5101.6 98.2,36.96 98.96,37.72 v2(98.96,37.73)
  vias: v1(20.25,28.14) v1(24.54,44.2) v2(18.57,35.1) v2(18.57,34.47) v2(18.57,33.83) v2(20.07,38.79) v2(48.4,40.02) v2(57.89,37.79) v2(110.19,29.28) v2(128.81,34.25) v2(129.32,33.74) v2(129.8,33.32) v2(171.01,39.42) v2(193.37,35.54) v2(194.03,35.54) v3(15.27,113.13) v3(15.27,112.45) v3(19.41,122.28) v3(23.13,29.9) v3(43.86,124.19) v3(43.93,123.02) v3(95.05,32.7) v4(15.83,88.06) v4(16.36,28.6) v4(16.56,24.97) v4(16.56,24.11) v4(16.81,88.05) v4(17.44,24.96) v4(17.43,24.11) v4(18.6,26.7) v4(20.09,38.05) v4(20.09,37.21) v4(23.45,30.59) v4(23.93,29.89) v4(24.29,30.66) v4(24.77,29.89) v4(25.12,30.66) v4(49.15,39.93) v4(49.98,39.96) v4(50.82,39.96) v4(55.55,37.92) v4(56.29,38.36) v4(56.31,37.52) v4(149.76,35.69) v4(170.26,39.45)
5V_TPAN_PWR: length 25.2
  TOP w0.508: v2(165.87,88.06) 165.48,87.68 R5502.2
  L6 w0.508: v2(159.11,106.81) 159.11,105.02 157.61,103.52 157.61,98.22 162.31,93.52 164.33,93.52 166.12,91.74 166.12,88.32 v2(165.87,88.06)
  vias: v1(159.74,106.57)
5V_TPAN_VDD: length 126.4
  TOP w0.305: AFTP5513.1 182.86,69.61 v2(182.89,69.58)
  L3 w0.508: v2(182.89,69.58) 183.54,68.93 186.08,68.93 186.81,68.78 187.57,68.45 189.68,66.35 209.05,66.35 209.69,66.99 219.85,66.99 221.21,68.35 223.22,68.35 224.54,67.03 224.54,61.52 223.6,60.58 223.6,45.94 v2(224.41,45.14)
  L6 w0.508: v2(182.89,69.58) 182.54,70.41 180.89,71.1 180.14,71.1 178.26,72.98 176.74,72.98 176.36,73.36 ; 175.03,74.39 169.74,79.68 169.29,79.68 167.52,81.46 167.52,92.24 165.29,94.46 162.27,94.46 158.5,98.23 158.5,102.02 159.34,102.86 159.34,104.26 160.81,105.73 v2(160.81,109.02) ; v2(220.23,44.92) 220.64,44.92 221.29,45.57 223.98,45.57 224.41,45.14 v2(224.41,45.14)
  BOTTOM w0.305: LCD1.25 220.1,45.05 v2(220.23,44.92)
5V_USB30_VCCA: length 2.5
  TOP w0.508: 13.14,35.64 USB2.1 14.46,34.5
  vias: v2(15.93,37.26) v2(15.93,36.6) v2(15.93,35.94)
5V_VCONN_EN: length 1.3
  TOP w0.089: R7205.2 45.96,124.3 46.15,124.48 U7202.3
5V_VCONN_P1:
  vias: v1(49.15,125.78)
5V_VCONN_P1_CCG4: length 19.2
  TOP w0.305: U7201.5 43.13,111.16 43.2,111.23 v2(43.21,111.23) ; v1(49,122.71) R7203.2
  TOP w0.508: R7203.2 49.4,123.62 49.45,123.67 49.66,123.67 v2(49.69,123.7)
  L5 w0.508: v2(43.21,111.23) 43.2,111.23 43.2,112.51 44.33,113.64 44.33,115.29 45.24,116.21 45.27,116.21 46.02,116.96 47.73,116.96 48.69,117.92 48.69,118.21 50.37,119.89 50.37,123.28 49.97,123.67 49.71,123.67 v2(49.69,123.7)
19V_AD+: length 369.3
  TOP w0.254: PR4473.1 210.37,43.46 v2(210.5,43.59)
  TOP w0.356: v2(29.26,96.09) 28.71,96.09 v1(28.65,96.04)
  L3 w0.305: v2(29.26,96.09) 29.57,96.09 30.08,95.58 30.08,94.34 31.14,93.28 39.27,93.28 40.49,92.06 40.49,77.09 36.73,73.33 35.66,73.33 34.81,72.48 34.27,72.48 30.25,72.48 28.84,71.07 26.47,71.07 24.49,69.09 24.49,67.13 24.26,66.9 24.26,62 24.12,61.86 24.12,61.84 22.81,60.53 22.81,59.08 19.73,56.01 19.73,49.57 19.4,49.24 19.4,42.86 18.82,42.28 18.82,36.86 19.94,35.74 19.94,29.42 23.71,25.66 30.62,25.66 31.85,24.42 31.85,24.12 32.17,23.8 v2(32.17,23.42)
  L5 w0.152: v2(32.17,23.42) 33.82,25.08 34.44,25.08 35.69,26.33 35.69,27.69 37.71,29.72 89.23,29.72 90.59,31.08 106.42,31.08 109.08,33.74 109.08,34.33 110.56,35.81 110.56,36.86 111.24,37.53 111.24,41.15 112.4,42.3 124.53,42.3 130.31,36.53 131.86,36.53 135.1,33.29 136.88,33.29 137.6,32.58 144.72,32.58 145.32,33.17 147.23,33.17 148.61,31.8 170.97,31.8 171.91,32.74 173.98,32.74 174.9,31.81 197.23,31.81 198.87,33.45 v2(202.57,33.45)
  L5 w0.305: v2(29.26,96.09) 29.24,96.11 28.71,96.11 27.74,97.09 27.74,97.51 27.69,97.57 27.69,97.65 23.75,101.59 23.75,107.49 23.24,108 23.24,110.92 24.29,111.96 24.29,119.58 23.41,120.46 23.41,123.79 30.38,130.76 v4(30.38,132.11)
  L6 w0.305: v2(210.5,43.59) 210.4,43.59 209.15,42.33 209.15,41.04 207.86,39.75 205.84,39.75 205.49,39.4 v2(205.49,38.33) 204.88,38.94 200.31,38.94 v2(198.83,40.42)
  BOTTOM w0.152: v2(205.49,38.33) 202.57,35.41 v2(202.57,33.45)
  BOTTOM w0.254: PR4464.2 192.59,42.5 PR4465.1 192.74,42.19 195.04,39.89 PD4408.1 196.43,40.42 v2(198.83,40.42) 198.83,40.59 PD4401.1
20V_DCBATOUT: length 6.9
  TOP w0.508: v2(196.85,54.14) 196.87,54.13 v1(196.87,53.47) PR4439.1
  BOTTOM w0.406: v2(196.85,54.14) 196.75,54.04 196.75,53.14 196.42,52.81 195.66,52.81 194.35,54.12 PU4403.5
20V_VCCPD_VBUS: length 48.5
  TOP w0.254: v2(10.67,118.11) 10.94,118.11 11.59,118.76 11.59,120.12 C7306.1
  TOP w0.305: v2(10.62,113.64) 10.54,113.72 AFTP7302.1 10.67,116.38 v2(10.67,118.11) ; v2(44.53,107.11) 44.66,107.24 R7201.2
  L3 w0.508: JUSB1.B9 7.78,122.4 ; JUSB1.B4 7.76,125
  L6 w0.508: v2(24.29,110.46) 24.29,109.65 27,106.93 27,103.03 28.38,101.66 31.78,101.66 32.24,102.11 32.24,104.6 33.23,105.59 42.7,105.59 44.22,107.11 v2(44.53,107.11)
  BOTTOM w0.254: v2(24.29,110.46) 24.08,110.26 24.08,109.5 R7425.1 R7426.1
  BOTTOM w0.305: JUSB1.B4 6.76,124.95 JUSB1.A9 ; R7423.1 27.23,116.1 26.65,115.52 26.22,115.52 v2(25.66,114.96) ; JUSB1.A4 6.76,122.45 JUSB1.B9 ; v2(10.62,113.64) 10.72,113.54 C7305.1
  vias: v1(12.04,124.72) v2(10.44,124.77) v4(39.17,127.31) v4(40.01,127.31) v4(40.9,127.31) v4(41.74,127.33)
20V_VCCPD_VBUS_R: length 6.9
  TOP w0.089: U7201.3 42.83,110.16 43.48,109.51 44.8,109.51 45.49,108.81 C7201.2 46.66,108.81 R7213.2 46.74,108.08 46.64,107.98 v1(46.38,107.98) 45.98,107.98 45.8,107.8 R7201.1
+1.8VALW_EC: length 3.7
  TOP w0.203: R2462.1 33.99,56.36 v1(34.19,56.57) 34.19,56.8 33.84,57.15 C2423.1 33.4,57.56 33.55,57.71 U2401.54
+3V_1D8V_DVDD: length 25.7
  TOP w0.203: 25.45,17.12 25.93,16.65 HDA27.8 ; v2(29.47,16.18) 29.39,16.26 HDA27.1
  TOP w0.305: v2(24.14,17.68) 24.29,17.68 24.67,17.3 C2741.1 25.28,17.3 25.45,17.12 ; v2(29.47,16.18) 29.57,16.18 R2717.1 30.25,17.58 C2721.1 30.23,17.65 C2723.1 C2720.1 ; v2(21.49,21.21) 21.49,20.63 R2710.1
  TOP w0.508: v1(27.38,21.79) 27.64,21.54 R2715.2 28.66,21.54 28.81,21.69 C2736.1 29.21,20.58 C2740.1 C2720.1
  BOTTOM w0.508: 25.3,18.64 24.38,17.73 24.23,17.73 24.18,17.68 v2(24.14,17.68) ; 25.3,18.64 28.65,18.64 30.13,17.17 30.13,16.84 v2(29.47,16.18) ; 25.3,18.64 23.37,20.58 21.89,20.58 21.49,20.97 v2(21.49,21.21)
+3VALW_EC: length 312.4
  TOP w0.203: 22.57,63.93 22.73,64.09 U2401.22 25.45,64.09 25.58,64.22 25.58,65.08 25.56,65.1 24.64,65.1 24.45,65.29 U2401.19 22.93,65.29 22.64,65 v2(22.38,65) ; U2401.115 30.36,74.73 30.13,74.96 v2(29.92,74.96) ; R2480.2 40.41,66.45 39.97,66.89 U2401.82 37.3,66.89 v2(36.53,66.12) 35.94,65.53 35.24,65.53 34.75,65.05 34.75,62.54 38.61,58.68 38.61,57.41 C2410.1 39.07,57.05 39.07,59.18 38.97,59.28 U2401.65 ; 35.15,74.85 U2401.103 ; U2401.5 v2(22.71,70.89) ; 29.16,57.54 U2401.43
  TOP w0.305: DBEC1.1 43.49,75.83 43.03,75.36 42.14,75.36 42.14,75.37 41.56,75.37 41.56,75.36 39.37,75.36 38.78,75.96 37.76,75.96 ; v2(29.92,74.96) C2412.1 29.92,76.56 29.59,76.89 v2(29.21,76.89) ; v2(34.01,77.8) 34.24,77.8 R2443.1 ; R2414.2 44.02,67.87 44.26,67.63 44.26,66.68 43.98,66.39 42.96,66.39 42.83,66.52 C2413.1 41.61,66.45 R2480.2 ; v2(28.73,56.31) 28.81,56.24 28.95,56.24 28.98,56.21 C2420.1 29.29,56.59 29.14,56.74 29.14,57.52 29.16,57.54 ; v2(20.81,64.11) 21.19,64.11 21.36,63.93 22.57,63.93
  TOP w0.508: 58.19,28.04 57.84,27.69 v1(56.67,27.69) 50.17,27.69 50.15,27.71 46.1,27.71 45.92,27.53 41.07,27.53 35.41,21.87 35.41,20.87 34.98,20.44 33.85,20.44 v2(32.91,19.5) ; v2(31.5,65.28) 31.04,65.74 31.04,66.66 30.29,67.41 28.6,67.41 26.27,65.08 25.58,65.08 ; 74.93,28.25 89.21,28.25 89.78,27.68 107.75,27.68 v2(107.83,27.75) ; v2(41.79,115.34) 41.91,115.22 R7215.1
  L3 w0.508: v2(20.81,64.11) 21.19,64.11 21.72,63.58 21.72,62.31 v2(22.29,61.75) 18.24,57.7 18.24,50.11 17.96,49.83 17.96,43.45 17.39,42.87 17.39,29.86 23.1,24.16 29.8,24.16 30.2,23.75 30.2,21.95 32.65,19.5 v2(32.91,19.5) ; v2(29.92,74.96) 29.6,74.96 28.94,74.3 27.26,74.3 26.85,73.89 25.4,73.89 24.64,73.13 24.64,72.82 v2(22.71,70.89) 23.19,70.41 23.19,67.59 23.09,67.49 23.09,67.46 23.04,67.41 23.04,65.33 22.71,65 v2(22.38,65)
  L5 w0.305: v2(34.41,110.75) 34.41,108.72 36.91,106.22 36.91,100.35 37.52,99.74 37.52,94.18 39.54,92.16 39.54,77.57 36.43,74.47 35.31,74.47 34.67,75.11 v2(34.17,75.11) 34.17,74.73 33.9,74.46 30.42,74.46 v2(29.92,74.96)
  L6 w0.305: v2(41.79,115.34) 40.16,113.72 35.7,113.72 34.41,112.43 v2(34.41,110.75)
  L6 w0.508: v2(28.73,56.31) 31.5,59.08 v2(31.5,65.28) 33.15,65.28 35.06,67.18 36.17,67.18 36.53,66.83 v2(36.53,66.12) ; v2(107.83,27.75) 108.31,27.27 121.21,27.27 122.48,28.54 122.48,35.41 123.29,36.22 v2(125.05,36.22)
  BOTTOM w0.254: v2(20.81,64.11) 20.4,64.52 R2608.1 20.02,64.49 C2411.1 ; v2(34.01,77.8) 34.01,77.76 32.96,76.71 29.39,76.71 v2(29.21,76.89)
  BOTTOM w0.305: C2429.1 22.94,65 v2(22.38,65)
  BOTTOM w0.508: ED4305.2 125.72,37.48 125.05,36.81 v2(125.05,36.22) 124.03,36.22 ED4304.2 124.02,36.23 ED4306.2 ; R2424.2 22.34,61.7 v2(22.29,61.75) 21.62,61.75 R2415.2
  vias: v1(60.02,27.87) v1(64.44,27.81) v1(68.53,27.81)
+5V_AVDD: length 6.6
  TOP w0.203: 24.03,11.97 HDA27.20
  TOP w0.254: R2703.1 18.6,11.91 20.88,11.91 C2707.1 21.8,11.41 C2706.1 23.19,11.41 v1(23.4,11.61) 23.76,11.97 24.03,11.97
+5V_KB_BL: length 8
  TOP w0.508: C6501.1 84.93,38.1 v2(85.34,38.51) v1(84.81,38.91)
  BOTTOM w0.305: v2(85.34,38.51) KBBL1.1 84.67,37.3
  BOTTOM w0.508: F6501.2 83.1,35.73 84.67,37.3
+5V_PVDD: length 5.2
  TOP w0.203: 31.98,12.12 31.88,12.22 30.81,12.22 29.86,13.17 HDA27.34 ; 30.96,15.56 30.12,15.56 30.1,15.55 29.72,15.17 HDA27.39
  TOP w0.508: C2714.1 31.98,12.12
  vias: v1(31.68,15.17)
GND: length 2757.9
  TOP w0.127: X3101.2 44.37,90.19 44.63,90.45 45.65,90.45 v2(45.67,90.48) 45.7,90.45 47.55,90.45 47.73,90.27 47.73,88.41 47.46,88.15 X3101.4 ; U7102.5 34.23,116.95 v2(35,116.18)
  TOP w0.152: R7219.2 36.68,111.43 36.53,111.58 36.53,111.91 v2(36.25,112.19)
  TOP w0.203: v2(38.05,84.48) 38.2,84.48 38.27,84.42 ED3202.3 ; U5802.61 50.9,117.63 U5802.11 ; U5802.61 52.95,117.83 54.1,116.68 U5802.19 ; U5802.61 49.3,119.23 U5802.52 ; R502.2 99.64,91.57 R501.2 99.32,91.9 v2(99.32,92.18) ; WWAN1.7 219.73,48.55 v2(220.14,48.13) ; U2401.100 36.35,74.69 v2(36.05,75) ; U3601.14 22.5,51.44 22.63,51.31 22.63,51.3 23.12,50.82 R3603.1 ; v2(37.77,67.82) 37.9,67.69 U2401.84 39.93,67.69 40.29,68.05 R2417.2 ; v2(26.77,72.9) 26.77,73 26.75,73.02 U2401.124 ; U2401.112 31.55,74.91 v2(31.77,75.12) ; U2401.17 22.81,66.09 v2(22.38,65.66) ; v2(38.08,58.19) 38.08,58.4 37.8,58.67 U2401.64 ; v2(32.49,56.52) C2423.2 32.49,57.84 32.35,57.97 U2401.51
  TOP w0.249: v2(156.01,145.74) 155.91,145.64 155.29,145.64 v2(155.21,145.71) 154.8,146.13 VRAM3.B10
  TOP w0.254: U3601.14 21.52,51.44 v2(20.76,51.69) ; v2(210.82,54.81) 210.65,54.99 EC6403.2 EC6401.2 ; v2(11.2,110.57) 11.81,111.18 R7185.2 ; EC2706.2 25.35,21.41 25.73,21.03 EC1901.1 25.89,20.87 v2(25.89,20.38) ; C2218.2 112.82,92.03 R2116.2 ; U7403.B3 U7403.C3 U7403.D3 41.13,123.07 v2(40.85,122.78) 40.63,122.57 U7419.B3 U7419.C3 U7419.D3 U7419.E3 ; EC2505.2 136.9,89.37 136.81,89.46 ; C2204.2 107.19,94.76 v2(107.21,94.78) ; v2(138.84,92.46) 138.27,91.89 R7011.2 ; v2(196.88,42.92) 196.21,42.92 195.35,43.78 PC4433.2 194.82,44.25 194.74,44.25 PC4431.2 ; v2(136.78,89.99) 136.81,89.97 136.81,89.46 ; v2(28.69,109.01) 29.17,108.53 Q7406.4 ; v2(162.26,69.65) 162.26,69.44 C9203.2 ; v2(111.56,124.49) 111.48,124.41 EC8923.2 FC8951.2 ; v2(41.13,117.6) 41.13,117.6 R4377.2 C4344.2 ; EC1803.1 102.16,80.39 v2(102.81,81.04) ; EC2702.2 22.94,3.15 23.35,2.74 ; R6122.2 36.83,104.75 v2(37.85,104.75) 37.85,104.18 R1516.2 ; C2225.2 115.57,88.95 v2(115.57,88.22) ; v2(103.96,91.42) 103.94,91.44 C2226.2 ; v2(103.96,91.42) 103.83,91.29 103.18,91.29 ; v2(103.96,91.42) 104.58,91.42 v2(104.6,91.45) C2207.2 ; R5810.1 v2(42.82,118.62) 42.85,118.65 R7418.2 ; v2(147.07,32.67) 147.37,32.97 EC8991.2 147.37,34 FC8901.2 ; C7213.2 44.15,112.5 C7208.2 44.85,112.35 v2(45.02,112.18) ; R7187.2 16.49,107.19 v2(16.49,106.61) ; 136.81,89.46 136.8,89.45 136.36,89.45 EC2504.2 ; C5810.1 45.37,121.08 R5814.1 ; v2(122.28,73.53) 123.18,73.53 123.31,73.66 123.31,77.73 123.11,77.93 121.14,77.93 120.96,77.75 v2(120.81,77.75) ; R7186.2 15.95,109.68 v2(15.89,109.74) ; ED7315.3 11.94,117.86 12.17,118.09 v2(12.17,119.53) 12.17,119.84 C7306.2 ; C2229.2 102.42,91.31 102.39,91.29 ; R2465.2 19.31,63.02 v2(18.57,63.76) ; 131.98,30.93 131.98,32.19 EC8992.2 ; C2228.2 105.9,91.45 v2(105.9,91.45) ; C2203.2 105.49,94.21 v2(105.25,93.97) ; C2230.2 103.3,92.44 v2(103.3,92.28) 103.43,92.15 C2213.2 ; v2(105.25,91.45) 105.26,91.46 C2227.2 ; 103.18,91.29 103.18,91.29 C1702.2 ; 103.18,91.29 102.39,91.29 ; ED6001.8 ED6001.3 v2(164.21,37.26) ; v2(106.56,91.44) 106.48,91.52 C2206.2 ; v2(106.57,94.8) 106.56,94.79 C2205.2 ; v2(115.47,103.72) 115.47,103.71 115.29,103.71 115.17,103.58 C2219.2 114.38,103.23 C2231.2 114.07,103.53 R5544.1 ; v2(57.92,114.99) 57.64,115.27 C5812.2 56.8,114.71 R5804.2 ; 102.39,91.29 102.03,90.93 R503.2 ; v2(208.61,60.48) 208.54,60.4 208.54,59.11
  TOP w0.305: PC4406.2 182.6,33.99 183.05,33.54 FC8914.2 ; EC1712.2 156.17,69.55 156.67,70.06 Q1701.4 ; 45.95,62.16 46.26,61.85 48.19,61.85 ; 45.95,62.16 46.38,62.59 EC8944.2 ; 45.95,62.16 44.73,62.16 v2(43.77,63.12) ; v2(78.18,38.08) 78.7,38.59 EC8935.2 80.17,37.81 FC8916.2 ; WWAN1.25 v2(219.82,57.55) ; v2(77.14,145.37) 77.2,145.31 PC4641.2 77.2,144.71 PC4644.2 78.78,144.71 PC4640.2 78.91,144.65 PR4655.1 ; C8014.2 130.42,134.49 v2(130.83,134.08) ; C1130.2 73.54,76.79 v2(73.23,77.09) ; C7403.2 46.93,123.3 47.35,122.89 v2(47.65,122.89) ; FC8993.2 100.08,95.54 C2216.2 100.04,94.71 C1121.2 100.06,93.73 100.42,93.37 100.5,93.37 100.51,93.36 C2201.2 100.85,93.36 101.35,93.86 v2(101.35,93.95) ; v2(163.2,118.63) VRAM2.E12 163.6,119.03 v2(164,118.64) ; v2(163.63,128.37) 163.63,128.35 163.6,128.32 VRAM2.E1 163.97,127.46 163.97,127.44 v2(163.98,127.43) ; VRAM3.C11 v2(156,146.53) VRAM3.D10 156.01,145.74 v2(156.01,145.74) ; v2(118.24,47.02) 118.57,46.69 EC1303.2 ; v2(22.13,21.24) 22.13,20.12 R2735.2 ; 165.2,126.22 VRAM2.C3 ; VRAM2.K2 159.49,127.14 159.49,127.72 VRAM2.K1 159.36,128.07 v2(159.36,128.37) ; R7130.1 36.93,119.97 v2(37.04,120.07) ; v2(137.77,77.47) 137.95,77.47 138.18,77.24 PR8505.2 ; v2(218.64,58.93) 218.52,59.05 WWAN1.28 ; FC8935.2 156.95,89.41 v2(156.57,89.79) ; R7405.1 41.34,119.92 41.35,119.91 v2(41.39,119.91) ; C1221.2 138.86,45.49 v2(138.79,45.43) ; Q4304.E 29.43,123.19 v2(29.77,123.19) ; v2(157.61,139.34) VRAM3.E1 v2(156.8,139.33) ; C1220.2 135.82,46.15 v2(135.33,46.15) ; U9103.23 164.74,79.65 v2(163.49,80.9) 161.74,79.15 U9103.16 ; R2444.2 C2408.2 33.3,77.12 v2(33.3,77.8) ; C1142.2 131.07,49.67 130.99,49.6 v2(130.99,48.97) ; FC8903.2 22.75,92.36 Q5701.S 22.2,93.22 v2(21.95,93.47) ; EC6503.2 110.95,35.92 112.17,34.7 PC5118.2 112.25,34.34 111.97,34.06 v4(111.97,33.22) ; v2(18.14,110.95) 17.71,111.38 R7330.1 ; v2(124.84,39.45) 124.77,39.45 124.64,39.32 FC8944.2 FC8939.2 FC8956.2 ; PC4621.1 73.41,146.03 v2(73.31,146.13) ; VRAM3.G5 v2(159.2,141.73) ; RN1201.2 70.54,42.67 69.98,42.11 v2(69.98,41.56) 69.47,41.56 69.2,41.82 FC8997.2 ; v2(195.02,65) 195.02,64.44 FC8902.2 ; v2(155.2,117.83) VRAM2.R14 v2(155.2,117.03) ; v2(71.86,91.55) 71.86,91.88 FC8904.2 ; C1321.2 73.71,49.02 v2(73.21,49.02) ; C2410.2 38.1,57.7 38.08,57.73 v2(38.08,58.19) ; Q8702.4 106.88,152.78 107.98,153.87 v2(107.98,154.76) ; VRAM2.R12 v2(156,118.63) ; C1303.2 69.84,76.91 v2(69.73,76.81) ; v2(29.2,48.81) 28.86,49.15 DBG1.16 27.31,52.17 EC2602.2 ; VRAM3.M5 v2(163.2,141.73) ; C1322.2 58.61,45.73 v2(59.13,45.73) ; C7205.2 43.96,126.38 v2(44.05,126.47) 44.38,126.47 C7206.2 44.88,125.97 U7202.1 46.4,125.97 U7202.7 ; VRAM2.M5 v2(157.6,125.03) ; v2(163.21,140.93) 163.6,140.54 VRAM3.N3 ; v2(111.46,48.8) 111.34,48.8 110.67,48.13 FC1102.2 ; v2(37.58,44.5) 37.36,44.71 C1316.2 ; v2(159.52,48.37) 159.51,48.36 EC8914.2 ; C1140.2 92.25,46.66 v2(91.78,46.66) ; EC2601.2 30.03,56.64 30.03,56.36 30.18,56.21 C2420.2 30.66,56.21 31.55,55.32 ED1706.1 32.49,56.25 v2(32.49,56.52) ; v2(18.67,122.3) 18.67,122.4 19.21,122.94 EC8949.2 ; 162.66,45.65 162.54,45.65 162.28,45.9 EC8915.2 ; 162.66,45.65 162.56,45.54 162.54,45.54 162.04,45.04 C1218.2 ; 162.66,45.65 v2(162.77,45.65) ; v2(13.54,125.48) 12.44,126.58 PQ4418.1 ; DBG1.15 42.7,49 v2(41.57,49) ; VRAM3.F5 v2(158.4,142.53) ; VRAM2.N14 157.21,117.43 v2(157.61,117.83) ; VRAM2.N14 157.2,117.44 v2(156.81,117.83) ; VRAM2.N14 v2(156.8,117.03) ; v2(198.95,57.81) 198.57,58.19 FC9001.2 ; v2(34.06,45.26) 34.13,45.33 34.42,45.33 C1318.2 ; EC8925.2 105.06,140.19 v2(105.29,140.43) ; DBEC1.8 46.06,72.8 43.44,72.8 42.99,73.24 ; v2(102.19,143.93) 102.25,143.87 Q8701.4 ; v2(163.98,139.31) VRAM3.N1 163.53,138.86 C8226.2 ; v2(219.79,55.55) 219.29,56.05 WWAN1.22 ; EC8964.1 178.91,63.16 EC8930.2 FC8954.2 FC8953.2 177.24,64.82 EC8955.2 ; EC8968.2 129.73,113.46 129.47,113.71 v2(129.47,114.28) ; v2(18.75,109.53) 18.75,109.27 18.42,108.94 R7331.1 ; v2(73.62,136.04) 73.8,135.87 PC4866.2 PC4812.2 ; v2(198.45,55.47) 198.48,55.45 R7432.2 198.5,54.89 EC8974.2 EC8971.2 ; C7120.2 33.94,122.35 v2(34.04,122.45) ; EC6501.2 108.51,36.37 AFTP6501.1 107.9,35.82 EC6504.2 106.63,36.04 v2(105.92,36.76) ; Q8702.1 108.54,150.83 109.02,150.34 C8803.2 109.94,149.99 v2(110.26,149.99) ; R7422.2 30.76,111.05 30.47,110.76 Q7406.1 30.47,109.21 30.27,109.01 v2(28.69,109.01) ; v2(154,149.89) VRAM3.A14 ; EC8948.2 19.31,97.87 19.66,97.51 20.45,97.51 v2(20.96,97) ; v2(203.46,60.45) EC8946.2 203.47,59.73 EC8936.2 ; v2(105.86,107.19) 106.55,106.5 R1603.2 ; v2(155.2,148.93) 155.6,148.53 VRAM3.C13 155.6,148.52 v2(156,148.13) VRAM3.C12 ; v2(72.8,101.07) C1107.2 ; v2(165.38,64.53) 165.38,64.85 165.72,65.18 ED1801.1 166.63,65.61 C1805.2 165.8,66.33 C2222.2 165.56,66.22 C2221.2 ; 168.71,64.19 169.07,63.83 169.07,63.04 v2(168.99,62.97) ; 168.71,64.19 168.52,64 ED1802.1 ; 168.71,64.19 168.71,64.51 169.26,65.06 G1801.1 169.26,66.87 C1806.2 ; v2(157.6,140.15) 157.58,140.15 VRAM3.E3 ; v2(49.58,86.94) 49.54,86.94 49.46,87.02 47.44,87.02 C3125.2 47.42,87.44 X3101.4 ; VRAM3.R12 v2(164.8,148.13) ; U8804.3 97.38,150.21 C8802.2 100.22,150.32 H14.1 ; v2(137.14,124.36) 136.4,124.36 C8049.2 ; v2(77.04,41.63) 76.43,41.63 EC8995.2 76.28,41.63 R1212.2 ; VRAM2.L5 158.8,124.26 v2(158.64,124.1) ; ED2911.3 ED2910.3 v2(21.31,5.03) 20.98,4.7 19.74,4.7 ; v2(154.4,140.13) VRAM3.A3 ; VRAM3.A3 v2(154.4,140.93) ; VRAM3.A3 v2(153.6,140.93) ; C8219.2 155.6,129.02 v2(155.6,128.39) VRAM2.R1 155.99,127.44 v2(156.03,127.44) ; v2(39.63,49.67) 39.61,49.69 DBG1.3 39.61,52.71 EC1801.2 ; EC8941.2 41.33,67.87 41.02,67.87 40.85,68.05 R2417.2 ; C3516.2 C3517.2 16.74,34.16 16.71,34.19 16.31,34.19 v2(16.28,34.22) ; v2(25.62,111.65) 25.63,111.66 R7102.1 ; R2705.2 v2(32.64,3.48) ; v2(164.8,121.03) VRAM2.D10 164.4,120.63 v2(164.8,120.23) 165.2,119.83 VRAM2.C11 ; VRAM3.P10 v2(164.8,146.53) VRAM3.R11 ; v2(103.29,94.79) 103.3,94.81 C2214.2 ; v2(161.91,145.59) 162,145.68 VRAM3.L10 ; D4302.1 25.6,91.46 24.74,90.6 v2(24.41,90.6) ; v2(69.9,100.96) 69.85,101.01 C1102.2 ; R1901.2 111.41,87.43 111.24,87.6 v2(111.24,87.76) 111.39,87.91 R2101.2 ; EC8972.2 31.98,109.84 Q7408.S 32.74,109.08 v2(33.79,109.08) 33.79,109.12 33.79,109.12 R7415.2 ; C1114.2 100.13,98.91 v2(100.26,98.78) 100.23,98.76 EC2201.2 ; PC5122.2 113.67,32.89 v4(113.64,32.87) ; v2(54.81,49.62) 54.21,49.62 C804.2 ; R7428.2 29.34,113.59 28.99,113.94 v2(28.96,113.94) 29.29,114.27 Q7407.1 28.81,114.59 28.4,115 28.4,115.77 28.29,115.89 Q7407.4 ; VRAM3.C4 v2(156,140.93) VRAM3.C3 ; C7210.2 39.5,104.98 40.06,104.42 41.2,104.42 41.91,105.13 C7212.2 ; VRAM3.U1 166.96,138.77 v2(166.96,138.25) ; C1317.2 48.67,49.58 v2(48.26,49.58) ; WWAN1.34 218.47,62.05 218.94,61.58 219.81,61.58 v2(220.32,61.06) ; v2(64.37,47.88) 64.47,47.78 C1141.2 ; C2210.2 107.22,97.77 v2(107.22,98.17) ; EC8963.1 197.84,40.9 198.4,41.46 198.96,41.46 200.59,43.09 v2(200.59,43.13) ; VRAM2.G5 v2(162.4,124.23) VRAM2.F5 v2(163.2,125.03) ; C1138.2 88.06,76.71 v2(88.09,76.68) ; v2(86.62,45.55) 85.9,45.55 C1315.2 ; VRAM2.A12 166.8,119.04 v2(166.41,119.43) ; v2(36.05,75) 36.46,75.41 C2414.2 ; v2(106.57,94.8) 106.34,95.03 C2202.2 ; C8049.2 136.37,124.59 C8036.2 ; C8049.2 136.07,124.39 C8028.2 ; VRAM3.L5 v2(162.4,141.73) ; FC8937.2 176.15,65.91 EC8955.2 ; v2(219.71,43.74) 219.71,43.84 WWAN1.36 ; R8111.1 161.42,128.7 v2(161.07,128.35) 161.2,128.22 VRAM2.H1 VRAM2.H2 ; VRAM3.A12 v2(154.42,147.31) ; VRAM3.A12 v2(154.4,148.13) ; VRAM3.A12 v2(153.58,147.31) ; VRAM3.A12 v2(153.6,148.13) 152.77,148.13 C7819.2 ; R2118.2 111.01,95.53 110.68,95.86 v2(110.68,95.94) ; v2(123.32,48.82) 124.03,48.82 C1139.2 ; v2(97.31,139.98) 97.31,140.44 97.47,140.6 U8802.3 ; v2(123.65,114.91) 123.65,114.86 124.42,114.09 U2601.5 ; VRAM3.F10 v2(157.6,145.73) ; v2(86.11,38.53) 86.11,38.28 85.85,38.02 C6501.2 ; C2425.1 28.25,77.17 v2(28.27,77.19) ; v2(24.08,56.34) v1(24.08,55.65) 24.08,54.91 23.86,54.69 C3602.2 ; v2(156.8,126.63) VRAM2.N3 v2(157.6,125.83) ; v2(160,140.12) 159.61,139.73 VRAM3.H2 159.49,139.62 159.49,139.04 VRAM3.H1 159.52,138.85 159.52,138.42 159.54,138.4 v2(159.54,138.39) ; FC8955.2 209.6,39.82 207.92,39.82 207.85,39.75 207.19,39.75 206.76,40.18 v2(206.76,40.31) 206.76,40.31 PR4474.1 ; R1205.2 94.65,45.04 v2(94.62,45.07) ; FC8907.2 54.88,32.12 v2(54.82,32.18) ; PC5307.2 68.28,40.92 v2(67.64,41.56) ; VRAM2.T10 v2(154.8,121.27) ; PC5121.2 EC8988.2 110.19,30.84 109.53,30.18 EC8993.2 ; v2(214.2,43.33) 213.57,43.33 EC5503.2 ; VRAM2.C1 v2(165.6,127.43) ; C1309.2 63.17,48.01 62.49,47.32 v2(62.33,47.32) ; v2(162.83,145.59) 162.82,145.61 162.82,146.1 162.8,146.12 VRAM3.M10 ; v2(17.12,66.93) 17.33,67.13 C2416.2 C2421.2 ; EC8994.2 54.08,32.08 v2(54.18,32.18) ; v2(203.52,37.83) 203.28,37.59 EC6601.2 ; v2(219.71,54.43) 219.32,54.05 WWAN1.18 ; ED5703.8 ED5703.3 v1(15.69,96.39) 14.61,96.39 v2(13.67,97.33) ; v2(131.78,44.44) 132.34,43.88 C1214.2 133.12,42.93 C1219.2 ; VRAM3.U12 v2(166.4,148.13) ; v2(98.15,146.03) 98.15,146.03 98.15,146.15 97.71,146.59 U8801.3 ; v2(86.45,105) 86.64,105.2 R708.2 ; R7404.2 35.54,121.87 v2(35.54,122.56) ; X3101.2 43.46,89.66 43.21,89.41 43.21,87.32 v2(43.99,86.54) 44.12,86.54 C3116.2 ; v2(217.88,41.99) 218.06,42.17 C5504.2 ; R1911.2 149.21,72.91 v2(149,72.7) ; VRAM3.T5 v2(166.41,142.54) ; v2(41.41,79.17) 41.2,79.38 R6413.1 ; C8809.2 101.35,146.81 101.2,146.66 v2(101.2,146.38) ; EC2708.2 EC2707.2 28.4,18.57 28.4,18.76 28.59,18.95 28.59,19.83 v2(28.32,20.09) EC1903.2 ; v2(158.85,65.91) 158.87,65.93 158.87,67.5 157.89,68.48 157.89,68.8 157.09,69.6 Q1701.4 ; C7616.2 126.5,133.58 v2(126.5,133.78) ; C2431.2 v2(30.69,77.78) ; C5811.2 43.36,116.18 R5808.1 ; v2(130.62,139.08) 130.62,136.26 130.58,136.22 C7629.2 ; v2(166.4,125.02) 166.01,124.63 VRAM2.B5 166,124.62 v2(166.41,124.21) ; EC8955.2 177.96,66.65 178.46,66.65 v2(178.76,66.95) ; v2(86.82,41.45) 86.39,41.02 C1703.2 ; v2(153.24,44.4) 153.12,44.4 152.78,44.73 C1217.2 ; C4302.2 25.76,123.09 v2(25.61,123.09) ; C8805.2 93.58,146.46 94.86,147.74 ED2403.3 94.93,148.33 v2(94.29,148.97) ; U8803.3 105.3,148.5 105.4,148.61 v4(105.41,148.61) ; C1225.2 C1226.2 97.82,40.23 v2(97.82,39.63) ; U2402.3 45.51,53.58 45.05,54.04 45.05,55.39 45.22,55.56 45.97,55.56 46.13,55.4 46.76,55.4 47.23,55.88 47.23,56.54 C2432.2 47.19,57.68 47.83,58.32 48.37,58.32 48.93,58.88 48.93,61.1 48.19,61.85 ; v2(132.36,100.96) 132.21,101.12 R7927.2 131.7,102.9 EC8997.2 ; v2(26.39,75.15) 26.27,75.28 26.27,75.53 25.78,76.02 C2424.1 25.71,76.18 C2426.2 ; USB2.10 7.88,23.15 ; VRAM3.E12 v2(156.82,148.11) ; v2(154.8,124.1) VRAM2.T5 ; v2(165.6,148.93) VRAM3.R14 165.5,149.63 v2(165.5,149.81) 165.53,149.85 C8220.2 ; C2720.2 31.14,18.8 C2723.2 31.12,18.37 C2721.2 31.45,17.63 v2(31.65,17.83) ; v2(161.58,149.71) VRAM3.K14 161.2,149.28 v2(161.58,148.91) VRAM3.K13 ; VRAM3.C14 155.6,149.74 v2(155.47,149.87) ; v2(67.67,99.04) 67.67,99.82 C1105.2 68.29,99.86 FC8990.2 ; v2(114.33,95.23) 114.3,95.25 113.74,95.25 R2112.2 ; v2(153.6,117.03) VRAM2.U14 153.62,117.81 152.63,117.81 ; v2(165.08,116.88) 165.08,116.89 165.2,117 VRAM2.C14 ; PQ4418.4 11.11,124.67 v2(10.49,124.05) ; v2(129.43,124.92) 129.32,125.03 C7902.2 ; v2(57.83,48.37) 58.38,48.37 58.6,48.59 C1304.2 ; EC4311.2 ED4303.1 16.92,124.51 v2(16.34,125.1) ; v2(160,148.12) 159.6,148.52 VRAM3.H13 159.72,148.65 159.72,149.21 VRAM3.H14 v2(159.6,149.86) 159.6,150.06 159.21,150.45 R8212.2 ; R7129.1 31.37,120.22 30.91,119.76 v2(30.69,119.76) 30.66,119.74 Q4449.4 28.91,119.74 28.68,119.97 28.68,120.84 28.48,121.04 Q4449.1 27.89,121.26 R4312.2 ; FC8938.2 137.26,98.71 v2(137.67,99.11) ; Q1701.4 157.09,70.53 157.41,70.84 158.12,70.84 158.39,71.12 Q1701.1 ; v2(223.55,66.19) 223.22,65.86 C9202.2 C9201.2 ; C1136.2 82.68,76.84 v2(82.53,76.69) ; R8107.2 159.08,115.85 C8103.2 159.06,116.82 v2(159.25,117.02) 159.25,117.09 VRAM2.K14 ; v2(165.31,138.38) 165.31,138.82 VRAM3.R1 ; VRAM3.K2 VRAM3.K1 161.2,138.41 161.25,138.36 v2(161.25,138.36) 161.25,138.07 R8211.1 ; 48.19,61.85 48.19,62.71 49.28,63.81 49.36,63.81 Q5505.2 ; R2114.2 108.39,91.08 107.98,91.49 v2(107.98,91.64) ; VRAM3.A1 v2(154,138.37) 154,137.46 C8224.2 ; PC4606.2 74.07,152.22 74.07,151.06 74.38,150.75 74.85,150.75 75.06,150.54 v2(75.11,150.54) ; v2(45.72,110.54) 45.14,109.96 C7209.2 ; 143.51,44.32 143.21,44.32 C1215.2 ; VRAM2.R3 155.2,125.83 v2(155.2,125.79) 155.56,125.43 VRAM2.R4 ; v2(105.27,97.31) 105.41,97.45 C2220.2 ; EC8975.2 173.1,43.54 R1307.2 173.71,43.51 v2(173.82,43.41) 173.82,43.13 174.16,42.79 175.2,42.79 175.41,43 C1325.2 175.41,43.4 C1324.2 175.41,45.01 C1327.2 175.55,45.51 C1326.2 175.55,47.26 174.25,48.57 ; v2(91.24,91.77) 91.37,91.64 PC1018.2 ; v2(88.73,38.51) 88.9,38.33 C6510.2 ; EC8966.2 138.33,97.44 138.33,96.54 137.66,95.87 Q7001.1 137.8,95.35 138.1,95.05 v2(138.1,94.49) 136.6,94.49 136.36,94.24 Q7001.4 ; v2(73.79,91.54) 73.97,91.72 FC8991.2 ; R809.2 95.99,104.71 v2(96.28,105) ; C4011.2 C4002.2 69.04,38.43 v2(69.55,37.92) ; VRAM3.R4 v2(164.8,140.93) VRAM3.R3 ; v2(28.68,74.93) 29.01,75.26 C2412.2 ; DBEC1.4 43.47,74.33 43.46,74.32 42.28,74.32 v2(42.17,74.21) 42.99,73.38 42.99,73.24 ; 219.49,68.78 220.25,68.02 R5552.2 221.16,68.02 C5535.2 ; Q5504.2 50.89,60.57 50.22,61.24 50.22,62.26 49.37,63.11 Q5505.2 ; EC8962.2 FC8957.2 140.16,38.99 FC8995.2 134.82,38.99 133.78,37.95 EC4309.2 ; R1311.2 RN1301.2 149.3,43.41 C1301.2 149.46,43.84 v2(150.04,44.43) ; VRAM2.H13 VRAM2.H14 v2(161.2,116.9) 161.47,116.63 R8113.2 ; v2(157.57,148.93) 157.2,149.31 VRAM3.E14 157.23,149.36 v2(157.23,149.86) ; Q8701.1 104.08,146.13 104.14,146.19 104.14,146.63 103.65,147.12 v2(103.64,147.12) ; v4(109.53,144.15) 109.25,144.15 C8808.2 ; BIOS2.9 137.56,83.11 BIOS2.4 ; VRAM2.N1 v2(157.2,128.36) ; C5505.2 215.24,46.51 215.34,46.41 215.34,45.73 EC5504.2 v2(214.61,45.72) ; 7.18,38.85 USB2.11 ; FC8994.2 162.55,49.69 v2(162.53,49.67) ; C4001.2 43.92,132.89 C4017.2 41.67,131.05 HS3.1 ; C1104.2 70.23,103.91 v2(70.18,103.87) ; ED2912.3 17.32,22.46 v2(17.05,22.73) ; C2714.2 32.41,13.08 C2718.2 v2(31.78,13.62) ; C5529.2 49.3,65.08 R5549.1 49.36,63.78 Q5505.2 ; PC5114.2 117.17,29.76 v2(116.59,29.18) 117.05,28.73 PC5123.2 ; C2407.2 39.07,77.6 R2441.2 37.7,77.6 C2435.2 37.54,77.75 v2(36.73,77.75) ; EC8996.2 167.62,40.29 v2(167.46,40.44) ; v2(58.65,118.64) 58.35,118.34 58.04,118.34 R5823.1 ; v2(106.56,91.44) 106.58,91.42 106.58,90.98 R305.2 ; EC8990.2 21.29,23.78 20.86,23.34 C6308.2 C6305.2 C6304.2 20.86,20.88 EC2704.2 EC2705.2 19.79,20.8 v2(19.28,21.31) ; v2(18.85,102.64) 18.82,102.62 18.75,102.62 18.34,102.21 C7165.1 17.94,101.88 C5736.1 ; C1137.2 92.09,76.89 v2(92.18,76.8) ; C1320.2 60.93,46.05 60.65,46.33 v2(60.61,46.33) 61.12,46.84 EC8902.2 ; v2(154.4,142.53) VRAM3.B5 ; C1228.2 96.57,48.01 96.88,48.31 C1207.2 97.29,48.31 97.56,48.03 C1231.2 98.63,48.03 99.14,47.52 99.14,46.41 98.5,45.77 EC8904.2 R1210.2 97.79,44.98 v2(97.79,45.64) ; C8050.2 134.63,124.9 133.92,124.19 C7906.2 ; VRAM2.U12 v2(154.4,119.43) ; FC8908.2 102.54,97.24 v2(102.64,97.34) ; v2(105.03,113.68) 104.93,113.78 104.93,115.27 ; v2(135.37,122.62) 136.39,122.62 R7907.1 ; EC8906.2 75.66,77.68 v2(75.34,77.68) ; v2(219.43,63.66) 219.81,63.27 WWAN1.35 ; FC8910.2 19.59,46.74 19.9,46.43 v2(19.97,46.43) ; C4010.2 101.4,72.24 C803.2 101.76,72.42 101.96,72.62 v2(102.21,72.62) ; C2224.2 144.44,70.23 R1521.2 144.48,70.08 144.12,69.72 v2(144.12,69.47) ; v2(157.87,121.28) 157.87,121.18 158,121.05 VRAM2.M10 ; C6102.2 47.42,101.96 EC8943.2 46.51,101.32 46.41,101.42 EC8959.2 45.22,101.42 44.46,102.19 v2(44.13,102.19) ; v2(166,121.2) 166,121.19 VRAM2.B10 ; v2(163.6,116.9) VRAM2.E14 163.6,117.45 v2(163.97,117.82) ; FC8986.2 28.02,101.96 v2(28.5,102.44) ; v2(43.46,44.97) 42.86,44.97 C1319.2 ; VRAM3.N12 v2(164,148.13) ; C8121.2 155.63,137.59 155.63,138.34 v2(155.6,138.37) VRAM3.C1 ; C4043.2 99.8,76.73 C4008.2 ; v2(73.71,101.07) 73.76,101.12 FC8906.2 ; v2(145.11,46.2) 145.95,46.2 EC1203.2 ; v2(157.61,72.7) 157.61,73.53 157.71,73.64 157.71,74.78 157.47,75.02 EC1707.2 157.12,75.01 156.49,75.01 Q1702.4 ; 42.99,73.24 42.55,72.8 C2406.2 C2405.2 ; EC4701.2 v2(71.38,103.56) ; v2(50.45,69.8) 50.45,69.75 50.98,69.22 C6405.2 ; v2(68.42,103.3) 68.42,103.89 68.47,103.93 FC8905.2 ; C8807.2 101.02,141.56 v2(100.79,141.78) ; VRAM2.A1 v2(167.37,127.83) ; Q1702.1 154.53,72.7 v2(154.25,72.7) ; VRAM2.R11 v2(156,120.23) VRAM2.P10 ; EC8947.2 v2(14.81,91.21) ; VRAM2.L10 v2(158.8,121.27) ; R7007.1 134.09,95.81 133.69,96.21 v2(133.51,96.21) ; WWAN1.31 218.39,60.55 v2(218.52,60.68) ; H13.1 63.7,143.42 ; v2(207.6,43.84) 207.6,44.38 PR4475.2 ; VRAM3.U3 v2(167.2,140.93) ; DBEC1.7 47.13,76.23 v2(47.4,76.23) ; v2(115.19,114.2) 115.65,114.66 C4012.2 115.1,115.92 U4006.5 ; PR4426.2 208,47.79 208.74,47.04 208.74,46.78 v2(208.73,46.76) 209.07,46.76 209.95,45.88 PR4436.2 ; v2(164,125.84) 163.99,125.84 VRAM2.E3 163.6,126.23 163.2,126.63 v2(163.17,126.63) ; VRAM2.C12 v2(164.8,118.63) VRAM2.C13 ; VRAM2.C4 165.2,125.43 v2(164.8,125.83) ; v2(164,148.93) VRAM3.N14 v2(163.2,148.93) ; VRAM2.U3 v2(153.6,126.63) ; v2(76.94,100.61) 76.75,100.8 C1106.2 ; v2(75.21,33.73) 75.21,34.11 74.86,34.47 R2449.1 73.92,35.33 74.27,35.69 AFTP6531.1 ; VRAM2.A14 v2(166.8,116.87) ; VRAM2.F10 v2(162.4,121.03) VRAM2.G10 ; VRAM3.G10 v2(159.2,146.53) ; v2(114.84,100.04) 114.54,99.75 C2223.2 C1116.2 112.95,99.36 C1122.2 112.95,98.91 113.94,97.92 C2211.2 114.34,97.92 v2(114.71,97.56) ; v2(139.96,47.58) 140.44,47.58 141.1,48.24 C1216.2 ; VRAM2.U1 v2(154.4,127.43) ; VRAM2.K13 v2(159.2,117.83) ; C2413.2 42.14,65.61 42.47,65.94 v2(42.47,65.95) 43.31,65.12 Q2408.S 42.92,64.43 ED1705.1 ; C5530.2 225.94,69.06 ; VRAM3.T10 v2(166.4,145.73) ; VRAM2.N12 v2(156.8,118.63) ; VRAM2.A3 v2(167.36,126.23) ; VRAM3.U14 v2(167.2,149.73)
  TOP w0.351: v2(164.8,125.83) 165.2,126.22
  TOP w0.356: v2(80.41,134.95) 80.19,134.95 79.66,135.48 PC4877.2
  TOP w0.381: FC8917.2 19.28,121.39 ED7307.3 ; Q7201.S 56.5,133.63 FC8911.2 ; R4302.2 20.86,96.9 v2(20.96,97) 21.5,97 Q4302.E
  TOP w0.399: v2(167.31,124.21) 167.22,124.12 166.5,124.12 v2(166.41,124.21)
  TOP w0.406: EC8908.2 169.19,50.01 169.19,49.35 168.72,48.87 v2(168.5,48.87) ; v2(94.72,73.85) 94.76,73.81 95.58,73.81 C4041.2 ; U4002.5 108.89,124.16 109.76,125.03 C1134.2 110.46,125.28 v2(110.54,125.2) ; C4010.2 100.52,72.51 U4003.5
  TOP w0.508: JUSB1.14 7.24,117.63 ; JUSB1.14 4.57,117.63 ; JUSB1.14 5.91,116.79 ; R4308.2 29.95,127.54 29.73,127.33 v2(29.73,127.01) 29.73,127 29.26,126.53 EC8969.2 ; 3.37,129.77 JUSB1.22 2.04,130.61 ; JUSB1.20 9.33,128.18 ; JUSB1.20 8.24,128.96 ; JUSB1.20 7.15,128.18 ; HS3.1 40.2,134.33 ; 6.71,125.93 JUSB1.B1 6.71,127.94 ; USB2.4 13.98,27.5 ; USB2.4 13.14,26.66 ; USB2.4 13.14,28.34 ; RJ1.9 10.55,85.89 ; RJ1.9 9.22,85.05 ; RJ1.9 11.88,85.05 ; v2(101.77,89.12) 101.78,89.12 101.79,89.11 R304.2 ; v2(141.23,119.71) 141.2,119.71 140.06,120.85 C8048.2 ; 2.75,85.89 RJ1.11 4.08,85.05 ; EC8907.2 83.77,76.96 C1136.2 ; 3.74,117.12 3.23,117.63 JUSB1.13 ; HDMI1.21 13.03,106.6 ; HDMI1.21 11.7,107.59 ; HDMI1.21 11.7,105.61 ; v2(195.84,37.77) 195.89,37.82 PR4447.2 ; 10.91,95.35 HDMI1.2 ; HDMI1.2 11.55,94.77 ; HDMI1.2 12.19,95.35 ; EC6502.2 102.72,31.01 102.52,30.81 v2(102.52,30.2) 102.49,30.18 C6505.2 ; v2(160.25,81.16) 159.97,81.16 159.72,81.41 C9104.2 ; USB1.12 13.68,49.25 ; USB1.12 12.24,50.14 ; USB1.12 12.24,48.36 ; PC5213.2 101.3,137.72 v2(102.57,138.99) ; EC8913.2 139.88,47.5 v2(139.96,47.58) ; v2(18.67,122.3) 18.67,122 ED7307.3 ; 29.16,6.53 29.48,6.21 v2(30.17,6.21) 30.08,6.3 C2704.2 30.08,8.61 C2705.2 ; v2(69.65,149.28) 69.65,149.56 70.46,150.36 71.27,150.36 71.54,150.09 PC4620.2 ; R4006.2 147.21,70.92 146.71,70.41 146.28,70.41 ; 146.28,70.41 C4009.2 ; 146.28,70.41 146.38,70.31 146.38,69.51 v2(146.37,69.51) ; R5808.1 42.8,116.21 v2(42.52,116.49) ; R2518.2 168.29,89.22 ; v2(199.96,37.8) 199.65,37.48 AFTP4307.1 ; 11.79,38.38 12.24,37.93 USB2.13 12.24,36.75 11.89,36.4 ; 4.57,129.77 JUSB1.21 ; JUSB1.21 5.91,130.61 ; JUSB1.21 7.24,129.77 ; Q9202.S 161.46,73.97 v2(162.08,73.97) ; v2(67.03,46.76) 67.38,46.76 67.85,47.22 C1307.2 ; EC1303.2 EC8912.2 ; v2(94.83,49.28) 95.05,49.51 R1216.2 ; R2504.2 158.2,96.28 ; 158.2,96.28 v2(158.25,96.32) ; 158.2,96.28 158.17,96.25 Q2505.S ; C2741.2 24.51,18.47 v2(24.13,18.47) ; v2(120.81,77.75) 120.81,77.24 C1803.2 ; USB1.10 5.44,43.37 H11.1 5.44,43.28 USB2.11 ; USB1.13 12.24,62.94 ; USB1.13 12.24,61.16 ; USB1.13 13.68,62.05 ; 10.55,67.41 RJ1.10 ; RJ1.10 11.88,68.25 ; RJ1.10 9.22,68.25 ; 111.89,147.52 111.89,148.36 v2(110.26,149.99) ; 111.89,147.52 112.32,147.09 FC8947.2 ; 111.89,147.52 111.53,147.17 EC8924.2 ; C4008.2 99.95,76.79 100.18,77.01 v2(100.64,77.01) ; Q2510.S v2(157.25,93.53) 158.06,93.53 158.3,93.3 R2517.2 ; v2(168.38,86.84) 168.23,86.69 FC8915.2 ; C1804.2 120.75,73.81 121.03,73.53 v2(122.28,73.53) ; EC8909.2 92.15,76.78 v2(92.18,76.8) ; v2(46.49,120.98) 46.46,121 46.41,121 46.39,121.01 46.21,121.01 46.11,121.11 R5814.1 45.65,121.36 C7404.2 ; v2(114.68,89.97) 114.68,89.97 114.51,90.15 C1123.2 C1113.2 111.99,91.2 C2218.2 111.46,91.26 110.96,91.75 v2(110.57,91.75) ; EC8901.2 v2(56,47.14) ; v2(109.56,114.12) 109.56,114.74 C4031.2 ; v2(96.52,77.16) 96.55,77.19 97.23,77.19 EC8910.2 ; 12.24,23.71 USB2.12 12.24,25.49 ; 3.5,109.49 HDMI1.23 4.83,108.5 ; EC8903.2 EC1202.2 109.2,45.26 109.2,45.62 v2(109.22,45.65) ; HDMI1.11 10.77,99.85 ; C4035.2 105.43,120.14 v2(105.39,120.09) ; JUSB1.B12 6.71,118.95 v2(6.66,118.9) ; v2(160.07,87.7) 160.59,87.7 161.12,87.17 C2604.2 161.77,87.04 D2601.A 162.46,85.7 R9101.1 ; EC8905.2 68.81,76.03 v2(69.24,75.6) ; USB1.4 13.14,52.99 ; USB1.4 13.98,52.15 ; USB1.4 13.14,51.31 ; C2722.2 v2(25.89,20.38) ; FC1103.2 135.32,48.22 135.5,48.22 v2(135.54,48.26) ; 12.19,98.35 HDMI1.8 10.91,98.35 ; C2736.2 30.53,20.58 C2740.2 C2720.2 ; HDMI1.20 13.03,92.1 ; HDMI1.20 11.7,91.11 ; HDMI1.20 11.7,93.09 ; RJ1.12 3.31,68.25 4.24,67.31 ; PC4766.2 63.95,135.03 v2(63.47,134.55) ; v2(18.6,70.89) 20.3,70.89 C2422.2 ; C2517.2 165.91,90.43 v2(165.48,90) ; C7615.2 123.41,130.48 122.81,130.48 v2(122.48,130.81) 122.48,131.21 C7624.2 ; v2(128.27,136.7) 128.27,136.83 C7632.2 ; EC2506.2 135.31,79.35 v2(135.11,79.15) ; 4.83,90.2 HDMI1.22 3.5,89.21 ; C7405.2 39.18,119.5 v2(39.22,119.46) ; R6804.2 86.87,36.04 v2(87.28,35.64) ; C1140.2 EC8911.2 ; EC8945.2 178.18,58.47 v2(178.19,58.47) ; v2(143.54,44.35) 143.51,44.32 R1309.2 ; 7.38,118.37 JUSB1.15 ; PD5101.A 114.1,31.45 ; v2(37.36,116.49) U4302.3 ; v2(142.29,76.4) PC8551.1 ; USB1.11 5.44,64.85
  L3 w0.076: v2(140.63,134.96) 141.19,134.96 142.42,133.74 v2(142.42,133.22) ; v2(141.23,130.74) 141.29,130.8 141.8,130.8 ; 141.8,130.8 142.38,130.21 v2(142.38,129.61) ; 141.8,130.8 142.37,131.37 v2(142.97,131.37) ; v2(126.5,133.78) 126.5,134.42 127.08,135 v2(127.08,135.54)
  L3 w0.305: v2(31.77,75.12) 32.38,75.12 33.45,76.2 34.67,76.2 35.29,76.82 36.33,76.82 36.73,77.22 v2(36.73,77.75) ; USB2.10 7.38,23.15
  L3 w0.508: v2(11.58,47.84) 12.24,48.5 USB1.12 12.24,50.04 11.94,50.34 ; 10.55,67.41 RJ1.10 ; RJ1.10 11.88,68.25 ; RJ1.10 9.22,68.25 ; 10.57,105.47 HDMI1.21 10.63,107.67 ; 4.83,108.5 HDMI1.23 3.5,109.49 ; 5.91,116.79 JUSB1.14 ; JUSB1.14 4.57,117.63 ; JUSB1.14 7.24,117.63 ; 11.94,61.01 12.24,61.31 USB1.13 12.24,63.57 ; USB2.12 13.68,24.6 ; USB2.12 12.24,23.71 ; USB2.12 12.24,25.49 ; USB2.4 13.14,28.34 ; USB2.4 13.98,27.5 ; USB2.4 13.14,26.66 ; 13.14,51.31 USB1.4 13.14,52.99 ; v2(6.66,118.9) 6.71,118.95 JUSB1.B12 ; RJ1.9 11.88,85.05 ; RJ1.9 10.55,85.89 ; RJ1.9 9.22,85.05 ; 8.24,128.96 JUSB1.20 7.15,128.18 ; JUSB1.21 5.91,130.61 ; JUSB1.21 4.57,129.77 ; JUSB1.21 7.24,129.77 ; 3.37,129.77 JUSB1.22 2.04,130.61 ; USB1.11 5.44,64.74 ; 4.83,90.2 HDMI1.22 3.5,89.21 ; 4.17,67.21 3.13,68.25 RJ1.12 ; HDMI1.20 13.03,92.1 ; HDMI1.20 11.7,91.11 ; HDMI1.20 11.7,93.09 ; 4.08,85.05 RJ1.11 2.75,85.89 ; USB2.11 5.44,40.31 ; HDMI1.11 10.7,99.85 ; USB1.10 5.44,46.61 ; 7.15,119.23 JUSB1.15 8.24,118.44 ; JUSB1.B1 6.71,128.4 v2(6.66,128.45) ; USB2.13 12.24,37.98 11.81,38.41
  L5 w0.089: 155.6,119.66 155.6,119.2 ; 141.07,130 141.05,130 140.75,129.7 ; 156.72,124.46 156.82,124.46 157.2,124.84 ; 137.22,140.07 137.7,139.59 ; 137.7,139.59 137.19,139.08 ; 137.7,139.59 137.87,139.42 137.87,139.42 138.22,139.07 ; 137.7,139.59 138.17,140.06 ; 137.03,140.1 136.63,139.7 ; 139.32,137.71 139.03,137.42 ; 139.29,124.8 138.99,124.49 ; 136.04,140.09 136.44,139.69 ; 154.81,146.73 154.81,146.3 ; 156.3,126.23 155.74,126.23 ; 140.44,137.66 140.24,137.46 139.81,137.46 139.55,137.72 ; 141.68,129.7 141.35,130.03 141.34,130.03 ; 137.2,138.9 137.58,138.52 ; 138.71,125.68 138.46,125.93 138.46,126.26 138.71,126.52 ; 142.79,127.15 142.52,126.89 ; 152.99,119.17 153.67,119.17 ; 143.66,132.69 143.99,133.02 ; 141.74,127.33 141.2,127.86 141.18,127.86 ; 144.22,130.92 144.53,131.23 ; 144.17,129.56 144.59,129.14 ; 160.4,141.49 160.4,142.05 ; 143.61,128.98 143.99,128.6 ; 139.02,139.42 139.29,139.15 ; 135.28,141.84 134.92,141.48 ; 157.2,141.25 157.2,140.65 ; 135.45,141.87 135.85,141.47 ; 157.2,119.84 157.2,119.83 157.81,119.83 ; 157.2,119.84 157.2,120.57 ; 157.2,119.84 156.97,119.84 156.97,119.83 156.54,119.83 ; 157.2,119.84 157.2,119.03 ; 157.01,140.53 156.52,140.53 ; 137.58,138.3 137.21,137.94 ; 143.68,131.2 143.97,130.91 ; 138.7,139.42 138.39,139.11 ; 155.79,117.43 156.28,117.43 ; 158.71,117.43 158.14,117.43 ; 142.22,127.75 141.92,127.45 ; 158.16,126.23 158.69,126.23 158.83,126.37 158.83,126.82 ; 136.43,141.81 136.08,141.47 ; 144.25,132.1 144.59,132.44 ; 141.18,127.86 141.18,127.87 141.62,128.31 ; 141.18,127.86 140.67,128.37 ; 141.18,127.86 141.18,127.85 140.76,127.43 ; 154.8,138.97 154.8,139.63 ; 141.93,130.63 142.22,130.33 ; 154.94,119.03 155.46,119.03 ; 158.03,117.31 158.03,116.8 ; 155.6,125.3 155.6,124.79 ; 157.08,146.91 156.63,146.91 ; 155.44,119.83 154.88,119.83 ; 158.03,140.64 158.03,141.28 ; 143.12,133.02 143.4,132.74 ; 139.58,127.41 140.02,127.86 ; 140.02,127.86 140.49,128.32 ; 140.02,127.86 139.58,128.3 ; 140.02,127.86 140.49,127.4 ; 156.4,119.14 156.4,119.7 ; 155.6,147.5 155.6,147.08 ; 141.34,138.25 141.63,137.95 ; 156.42,147.52 156.42,147.02 ; 155.59,140.53 154.85,140.53 ; 160.26,141.33 159.66,141.33 ; 154.87,147.73 155.38,147.73 ; 157.99,127.64 157.99,127.03 ; 157.99,127.03 157.99,126.19 ; 157.99,127.03 158,127.03 158.76,127.03 ; 134.9,141.26 135.3,140.87 ; 154.8,120.43 154.8,119.96 ; 139.87,124.23 139.59,123.95 ; 156.4,139.79 156.4,140.5 ; 142.84,130.63 142.56,130.35 142.56,130.3 ; 158.48,149.46 158.48,150.34 ; 143.14,130.61 143.44,130.31 ; 158.19,139.75 158.7,139.75 ; 155.46,146.92 154.96,146.92 ; 157.39,119.03 157.93,119.03 ; 163.72,141.33 164.28,141.33 ; 158,148.41 158,147.87 ; 141.08,137.35 140.73,137.7 ; 154.2,117.43 154.67,117.43 ; 157.19,127.75 157.19,127.19 ; 144.83,131.21 145.12,130.92 ; 138.71,125.37 138.42,125.08 ; 139.52,139.11 139.9,139.48 ; 157.2,146.75 157.2,146.27 ; 156.57,146.11 157.04,146.11
  L5 w0.305: USB2.10 7.39,23.15 ; v2(36.73,77.75) 36.73,77.71 36.25,77.23 33.83,77.23 33.3,77.76 v2(33.3,77.8)
  L5 w0.508: JUSB1.21 7.24,129.77 ; JUSB1.21 4.57,129.77 ; JUSB1.21 5.91,130.61 ; USB1.11 5.44,64.67 ; HDMI1.2 12.19,95.35 ; HDMI1.2 10.91,95.35 ; HDMI1.2 11.55,94.77 ; 4.37,67.11 3.23,68.25 RJ1.12 ; 12.24,36.51 USB2.13 12.24,38.29 ; 10.91,98.35 HDMI1.8 12.19,98.35 ; 4.83,90.2 HDMI1.22 3.5,89.21 ; HDMI1.20 11.7,93.09 ; HDMI1.20 13.03,92.1 ; HDMI1.20 11.7,91.11 ; H6.1 147.83,148.93 ; H6.1 143.46,148.93 ; H6.1 145.65,151.11 ; H6.1 145.65,146.74 ; 13.14,52.99 USB1.4 13.14,51.31 ; 9.22,85.05 RJ1.9 ; RJ1.9 10.55,85.89 ; RJ1.9 11.88,85.05 ; 4.57,117.63 JUSB1.14 ; JUSB1.14 5.91,116.79 ; JUSB1.14 7.24,117.63 ; 12.24,23.71 USB2.12 12.24,25.49 ; 7.15,128.18 JUSB1.20 ; JUSB1.20 8.24,128.96 ; JUSB1.20 9.33,128.18 ; USB1.13 12.24,62.94 ; USB1.13 13.68,62.05 ; USB1.13 12.24,61.16 ; 7.42,121.21 JUSB1.B12 6.71,118.95 v2(6.66,118.9) ; JUSB1.13 3.21,117.63 3.84,116.99 ; 13.14,26.66 USB2.4 13.14,28.34 ; 2.04,130.61 JUSB1.22 3.37,129.77 ; 4.83,108.5 HDMI1.23 3.5,109.49 ; USB2.11 5.44,40.21 ; 8.24,118.44 JUSB1.15 ; JUSB1.15 7.15,119.23 ; JUSB1.15 9.33,119.23 ; 4.08,85.05 RJ1.11 2.75,85.89 ; 11.7,105.61 HDMI1.21 13.03,106.6 ; HDMI1.11 10.77,99.85 ; 12.24,48.36 USB1.12 12.24,50.14 ; 9.22,68.25 RJ1.10 ; RJ1.10 10.55,67.41 ; RJ1.10 11.88,68.25 ; USB2.7 12.54,31 ; JUSB1.B1 6.71,128.4 v2(6.66,128.45) ; HDMI1.5 10.72,96.85 ; USB1.7 12.62,55.65 ; HDMI1.17 10.77,102.85 ; USB1.10 5.44,46.41
  L6 w0.305: USB2.10 7.39,23.15
  L6 w0.508: 5.44,46.68 USB1.10 ; HDMI1.20 11.7,93.09 ; HDMI1.20 13.03,92.1 ; HDMI1.20 11.7,91.11 ; RJ1.12 3.31,68.25 4.45,67.11 ; 3.37,129.77 JUSB1.22 2.04,130.61 ; USB1.13 12.24,62.8 v2(11.59,63.45) ; 8.24,118.44 JUSB1.15 7.15,119.23 ; HDMI1.21 13.03,106.6 ; HDMI1.21 11.7,105.61 ; HDMI1.21 11.7,107.59 ; v2(11.64,23.31) 12.24,23.91 USB2.12 ; 7.15,128.18 JUSB1.20 ; JUSB1.20 8.24,128.96 ; JUSB1.20 9.33,128.18 ; 3.5,109.49 HDMI1.23 4.83,108.5 ; 4.83,90.2 HDMI1.22 3.5,89.21 ; 5.91,116.79 JUSB1.14 ; JUSB1.14 4.57,117.63 ; JUSB1.14 7.24,117.63 ; JUSB1.B1 6.71,128.4 v2(6.66,128.45) ; HDMI1.2 12.19,95.35 ; HDMI1.2 10.91,95.35 ; HDMI1.2 11.55,94.77 ; 4.57,129.77 JUSB1.21 7.24,129.77 ; 4.08,85.05 RJ1.11 2.75,85.89 ; 9.22,85.05 RJ1.9 ; RJ1.9 11.88,85.05 ; RJ1.9 10.55,85.89 ; JUSB1.13 3.18,117.63 3.89,116.92 ; 12.24,47.93 USB1.12 12.24,50.04 11.92,50.37 ; USB1.4 13.14,51.14 ; 10.55,67.41 RJ1.10 ; RJ1.10 9.22,68.25 ; RJ1.10 11.88,68.25 ; 12.19,98.35 HDMI1.8 10.91,98.35 ; JUSB1.B12 6.71,118.95 v2(6.66,118.9) ; USB2.11 5.44,40.19 ; USB2.13 12.24,38.59 ; USB1.11 5.44,65.13
  BOTTOM w0.089: 67.04,87.15 67.03,87.15 66.43,86.54 v2(66.43,86.54)
  BOTTOM w0.09: v2(68.17,88.86) 68.34,88.86 68.34,88.86 CPU1.B29
  BOTTOM w0.102: v2(98.62,79.57) 98.62,79.72 96.42,81.92 96.42,83.31 96.29,83.63 96.29,84.16 CPU1.BF36 ; CPU1.AV36 91.21,84.15 91.21,80.49 v2(90.6,79.88) ; CPU1.BD36 95.02,83.57 95.21,83.38 95.21,80.71 v2(95.63,80.29) ; v2(81.14,82.17) 81.15,82.17 81.15,84.16 CPU1.AB36 ; C7907.1 153.33,111.8 151.84,113.29 151.84,114.1 v2(151.49,114.45) ; CPU1.B27 69.24,90.11 68.35,90.11 v2(68.14,90.32) ; CPU1.B31 69.24,87.61 67.93,87.61 67.62,87.3 67.19,87.3 67.04,87.15 ; CPU1.CP35 112.62,84.83 112.62,84.41 112.45,84.24 CPU1.CN37 ; CPU1.AP36 88.72,83.57 88.88,83.41 88.88,80.62 v2(88.15,79.89) ; v2(83.47,82.22) 83.5,82.22 83.69,82.41 CPU1.AF36 ; 93.91,83.06 93.91,83.39 93.78,83.52 93.78,83.9 93.76,83.92 CPU1.BB36
  BOTTOM w0.127: CPU1.G27 72.21,90.21 72.9,90.21 CPU1.H27 ; CPU1.BM36 CPU1.BM35 ; X7901.4 156.42,111.54 157.1,112.22 158.68,112.22 158.8,112.09 158.8,111.3 v2(158.93,111.18) ; CPU1.AF33 CPU1.AH33 ; v2(94.76,78.3) 93.91,79.15 93.91,83.06 ; R1817.2 121.96,115.84 121.17,115.84 C1807.1 121.08,114.89 121.08,113.98 119.89,112.79 v2(119.89,112.27) ; CPU1.BT5 102.33,104.19 102.16,104.36 v2(102.15,104.36) 102.15,104.35 102.03,104.23 101.27,104.23 CPU1.BP4 ; v2(73.36,82.94) 73.36,83.1 73.62,83.36 CPU1.J36 ; CPU1.L33 v2(74.88,85.53) CPU1.L35 ; CPU1.A32 68.63,86.64 v2(68.42,86.64) ; CPU1.E29 CPU1.E31 CPU1.E33 ; Q8705.1 104.33,143.52 103.83,144.02 102.28,144.02 v2(102.19,143.93) ; v2(110.33,106.97) 110.33,106.97 111.28,107.93 111.79,107.93 113.46,109.6 v2(114.56,109.6) ; JUSB1.19 8.53,126.69 8.29,126.45 JUSB1.A12 7.15,126.45 JUSB1.B1 ; 69.34,93.9 CPU1.B21 CPU1.C21 ; R5812.1 57.13,117.05 C4004.2 ; v2(114.13,107.95) 113.13,107.95 112.19,107.01 v2(111.92,107.01) ; CPU1.CB2 105.88,106.76 105.86,106.78 v2(105.86,107.19) ; CPU1.BE30 CPU1.BE31
  BOTTOM w0.15: 140,124.98 v2(139.98,124.98) v2(139.42,125.54)
  BOTTOM w0.152: v2(77.61,83.48) 77.53,83.57 77.53,84.14 CPU1.T36 ; v2(78.21,82.22) 78.21,82.63 78.64,83.06 78.64,84.16 CPU1.V36 ; v2(111.12,106.93) 111.12,106.8 CPU1.CK1 ; v2(114.84,100.04) 114.66,100.21 CPU1.CP11 ; v2(145.82,133.15) 145.81,133.14 145.81,133.14 ; v2(96.25,88.54) 95.86,88.15 CPU1.BE30 ; v2(98.51,107.17) 98.56,107.12 CPU1.BK2 CPU1.BK3 ; CPU1.CB2 CPU1.CB3 CPU1.CB4
  BOTTOM w0.178: v2(87.14,89.17) 87.42,89.45 CPU1.AM28 ; v2(85.32,89.17) CPU1.AJ28 ; v2(88.07,86.38) 88.47,86.38 CPU1.AP33 ; CPU1.T33 77.68,86.41 v2(77.83,86.41) 78.11,86.13 CPU1.V33 78.69,86.09 79.13,86.09 79.17,86.14 79.91,86.14 CPU1.Y33 80.38,86.13 80.38,86.14 81.17,86.14 CPU1.AB33 81.18,86.14 82.43,86.14 CPU1.AD33 ; CPU1.BD33 95.48,86.13 95.49,86.14 95.76,86.14 95.77,86.13 CPU1.BF33 ; v2(98.08,86.5) 98.42,86.5 CPU1.BK33 ; CPU1.AV33 91.75,86.13 91.75,86.14 92.03,86.14 92.03,86.13 CPU1.AY33 92.5,86.14 93.39,86.14 93.39,86.13 CPU1.BB33 93.76,86.22 93.97,86.43 93.97,86.67 93.97,86.68 CPU1.BC32
  BOTTOM w0.18: v2(108.41,107.14) 108.33,107.05 CPU1.CF2 CPU1.CF3 ; CPU1.B23 69.24,92.64 68.72,92.64 68.66,92.65 68.6,92.7 68.37,92.7 v2(67.3,92.91) ; CPU1.CP27 113.85,90.13 114.53,90.13 114.68,89.97 v2(114.68,89.97) ; CPU1.B7 68.97,102.74 68.42,103.28 v2(68.42,103.3) ; v2(86.36,82.37) 86.26,82.47 86.26,83.84 86.21,84 CPU1.AK36 ; CPU1.P36 76.14,83.09 v2(76.06,83.02)
  BOTTOM w0.2: CPU1.AW29 v2(92.61,88.54) ; v2(106.28,87.22) 106.45,87.22 CPU1.CC31 ; CPU1.CB7 106.15,102.49 106.45,102.19 106.53,102.19 v2(106.55,102.17) ; CPU1.BW7 104.53,102.67 104.55,102.71 v2(104.69,102.81) ; CPU1.BM35 CPU1.BM33 99.82,86.13 v2(99.59,86.36) ; v2(87.14,89.17) CPU1.AL28 ; CPU1.BE29 v2(96.25,88.54) ; CPU1.CC28 107.04,89.76 v2(107.16,89.76) ; CPU1.P3 CPU1.P4 ; CPU1.AU28 v2(90.78,89.17) ; v2(96.28,105) 96.28,105.35 CPU1.BF3 ; v2(89.87,89.18) 89.84,89.18 89.82,89.21 CPU1.AR28 ; CPU1.BW15 v2(104.6,97.32) CPU1.BY15 ; CPU1.C29 CPU1.B29 ; CPU1.BJ7 v2(98.16,102.72) ; v2(107.18,99.84) 107.18,99.92 CPU1.CD11 ; CPU1.K28 v2(73.47,89.17) ; CPU1.BA28 v2(93.52,89.17) ; CPU1.BY36 CPU1.BY35 CPU1.BY33 ; CPU1.BL7 99.91,102.13 v2(99.97,102.13) ; v2(81.56,102.73) 81.56,102.73 CPU1.AB7 ; CPU1.BE28 v2(96.25,89.17) CPU1.BG28 ; v2(88.93,102.07) CPU1.AN8 ; v2(85.32,88.54) 85.26,88.6 85.21,88.6 CPU1.AH29 ; CPU1.BY28 105.29,89.22 105.3,89.18 105.32,89.16 v2(105.32,89.14) ; v2(101.93,102.16) 101.73,102.16 CPU1.BP7 ; v2(107.41,102.72) CPU1.CC7 ; CPU1.AV8 v2(91.7,102.09) ; CPU1.AH28 v2(85.32,89.17) ; v2(88.93,102.72) CPU1.AN7 ; CPU1.K3 CPU1.K4 ; v2(94.43,88.54) CPU1.BC29 ; CPU1.BH29 v2(98.08,88.54) ; CPU1.BU7 103.6,102.18 103.64,102.18 v2(103.65,102.18) ; CPU1.CF4 CPU1.CF3 ; CPU1.AF7 84.15,102.19 v2(84.28,102.19) ; CPU1.BD33 v2(95.02,85.53) ; CPU1.BH28 v2(98.08,89.17) ; CPU1.AV28 v2(91.7,89.17) ; CPU1.BC8 94.47,102.09 ; CPU1.AW28 v2(92.61,89.17) ; CPU1.BK7 v2(99.09,102.72) ; v2(107.2,91.45) CPU1.CC24
  BOTTOM w0.203: CPU1.BL25 99.44,92.06 v2(99.32,92.18) ; SSD1.57 22.45,31.81 22.69,31.57 23.79,31.57 23.95,31.74 SSD1.51 ; JUSB1.B12 7.15,120.95 JUSB1.A1 8.31,120.95 8.53,120.73 JUSB1.16 ; PU5102.4 115.9,27.17 ; CPU1.AW1 CPU1.AV3 ; SSD1.45 25.45,31.81 26.19,31.07 26.65,31.07 26.95,31.37 ; v2(73.41,88.48) 73.41,88.48 CPU1.K30 ; v2(38.05,84.48) 38.1,84.48 38.26,84.63 39.04,84.63 C3203.2 39.42,84.41 ED3201.8 ; DM1.223 87.83,49.9 87.95,49.78 v2(87.95,47.94) ; CPU1.C29 v2(70.62,88.86) CPU1.E29 ; v2(116.59,29.18) 116.85,29.44 PU5102.30 ; 119.17,28.64 PU5102.32 ; v2(15.83,43.61) 16.03,43.81 16.86,43.81 ED3503.3 ED3503.8 ; LCD1.17 219.41,49.05 220.14,48.31 v2(220.14,48.13) ; R403.1 126.62,99.75 v2(127.05,99.75) 127.53,100.23 Q401.4 ; CPU1.J33 73.62,86.55 CPU1.K32 CPU1.K31 ; CPU1.P3 76.28,105.82 76.28,106.66 75.82,107.11 v2(75.82,107.34) ; U8601.11 v2(164.9,109.37) ; CPU1.CM33 111.26,86.69 111.26,87.74 v2(111.24,87.76) ; R3604.1 21.87,51.69 v2(20.76,51.69) ; v2(159.36,128.37) 159.11,128.62 159.11,129.45 R7820.1 ; U4004.11 v2(59.59,37.85) ; CPU1.BP3 CPU1.BP4 ; JUSB1.17 8.72,122.7 9,122.43 v2(9.07,122.43) ; GPU1.E11 137.68,124.92 138.67,123.93 138.67,123.37 GPU1.B11 ; v2(114.71,97.56) 114.26,97.56 114.12,97.69 CPU1.CP15 ; v2(157.48,105.39) U5503.15 U5503.11 ; CPU1.BF4 96.28,104.65 v2(96.28,105) 96.31,105 CPU1.BG4 ; CPU1.L35 CPU1.L36 ; CPU1.CJ36 CPU1.CJ35 ; CPU1.BK4 CPU1.BK3
  BOTTOM w0.249: v2(154.4,145.72) VRAM3.B10 154.8,146.13 v2(155.21,145.71) 155.28,145.65 155.93,145.65 v2(156.01,145.74)
  BOTTOM w0.254: CPU1.BT25 102.44,91.14 102.86,91.14 CPU1.BU25 CPU1.BU24 ; v2(100.76,87.84) 100.74,87.84 100.68,87.9 100.6,87.9 CPU1.BN30 ; v2(39.6,40.18) 39.59,40.17 39.59,39.59 PR4551.2 ; v2(39.6,40.18) 40.12,40.7 40.97,40.7 41.2,40.46 PC4520.2 41.38,40.48 PC4524.2 ; v2(39.6,40.18) 39.4,40.39 PC4531.2 37.11,40.39 PR4513.2 ; LCD1.11 219.48,52.05 v2(219.84,52.42) ; CPU1.AM5 87.8,103.53 v2(88.01,103.53) 88.01,103.89 88.6,104.47 ; v2(127.51,78.39) 127.59,78.31 C2502.2 128.93,78.31 C2501.2 ; v2(107.98,91.64) 107.98,91.9 CPU1.CF23 ; ED7314.1 13.41,119.53 v2(12.17,119.53) ; v2(44.95,96.37) WLAN1.57 ; LCD1.41 219.42,57.95 v2(219.82,57.55) ; CPU1.CJ19 109.87,94.96 v2(109.87,94.93) ; C2411.2 v2(18.57,63.76) ; GPU1.AE14 126.59,138.41 v2(126.57,138.43) GPU1.AF14 ; GPU1.E2 131.83,119.71 v2(130.71,118.59) ; CPU1.AB30 81.54,87.98 81.6,87.98 v2(81.67,87.9) CPU1.AC30 ; CPU1.CJ23 110.45,91.92 110.57,91.81 v2(110.57,91.75) ; CPU1.CN9 CPU1.CP9 113.16,101.47 113.4,101.23 v2(114.61,101.23) ; C8804.2 102.7,143.42 v2(102.19,143.93) ; CPU1.Y35 v2(79.91,85.53) CPU1.Y33 ; v2(89.97,104.24) CPU1.AR4 ; v2(89.97,104.24) CPU1.AU4 CPU1.AV4 v2(91.34,105) ; v2(89.97,104.24) CPU1.AT4 ; CPU1.CN17 CPU1.CM17 111.04,95.86 110.75,95.86 v2(110.68,95.94) ; CPU1.AM33 v2(87.46,85.45) CPU1.AM35 ; GPU1.AD12 126.55,137.23 126.57,137.25 v2(126.57,137.26) ; CPU1.CE36 107.6,83.34 v2(107.7,83.24) ; CPU1.AT33 89.98,85.47 v2(89.98,85.46) 89.98,85.46 CPU1.AT35 CPU1.AT36 ; v2(22.38,65.66) 22.41,65.66 22.58,65.84 C2429.2 23.04,65.86 C2418.2 ; SSD1.9 34.45,33.78 34.31,33.92 v2(34.31,33.94) ; v2(66.55,140.87) 66.58,140.84 PC4708.2 ; CPU1.AY4 CPU1.BA3 ; CPU1.AY4 CPU1.AW3 v2(91.34,105) ; CPU1.AY4 CPU1.AW4 v2(91.71,104.03) ; USB1.7 13.62,55.65 14.28,54.99 14.28,53.93 14.91,53.29 ED3501.3 ED3501.8 ; v2(210.82,54.81) 211.48,54.15 ED6401.3 ; GPU1.AB17 v2(130.62,139.08) ; GPU1.AC5 123.04,131.37 v2(122.48,130.81) ; CPU1.G33 72.42,85.62 v2(72.42,85.59) 72.38,85.55 72.38,85.11 CPU1.G35 CPU1.G36 ; CPU1.BY33 105.04,86.17 103.87,86.17 CPU1.BV33 ; v2(127.08,135.54) 127.11,135.5 GPU1.AB11 ; v2(185.67,40.32) 185.68,40.32 185.7,40.3 ODD1.3 ; v2(132.36,146.58) 132.97,146.58 GPU1.AG26 ; 36.2,33.5 35.77,33.94 v2(35.73,33.94) 35.61,34.05 FC8921.2 ; 36.2,33.5 36.45,33.25 SSD1.1 ; 36.2,33.5 35.95,33.26 SSD1.3 ; CPU1.CJ14 109.93,98.13 v2(109.93,97.96) ; CPU1.BD7 94.93,102.44 94.52,102.08 94.47,102.09 ; v2(102.81,81.04) 102.81,81.52 101.31,83.02 CPU1.BP36 ; ED7311.1 12.17,122.51 12.93,121.74 v2(12.93,121.57) 13.13,121.77 ED7313.1 ; ODD1.10 190.56,36.8 v2(191.21,37.46) ; CPU1.N6 75.24,103.43 75.03,103.43 v2(75.01,103.46) ; v2(9.91,116.77) 10.49,116.18 ED7301.8 ED7301.3 ; CPU1.AH35 v2(84.95,85.53) CPU1.AH33 ; v2(36.07,45.72) 36.14,45.72 36.58,45.28 36.58,44.22 36.58,44.22 DM1.26 ; v2(37.3,49) 37.36,49 37.83,49.47 DM1.31 ; v2(87.08,102.79) 86.92,102.79 CPU1.AL7 CPU1.AJ7 ; WLAN1.63 v2(46.45,96.37) ; PC8552.1 149.02,78.21 v2(148.59,77.78) ; v2(137.75,119.58) 137.75,120.53 137.07,121.2 GPU1.B8 ; v2(208.94,51.56) 208.49,51.56 PC4419.2 PC4422.2 ; CPU1.C9 69.99,101.06 v2(69.9,100.96) ; v2(73.71,101.07) 73.84,101.07 CPU1.K9 ; R7901.2 140.8,120.14 v2(141.23,119.71) ; v2(125.33,133.82) 124.81,133.82 GPU1.AC8 ; v2(103.65,102.18) 103.86,102.18 CPU1.BW7 104.5,102.16 v2(104.7,102.16) 104.65,102.11 v2(104.65,101.53) v2(104.65,100.89) ; v2(77.09,88.49) 77.44,88.15 CPU1.T30 ; GPU1.AD21 v2(131.81,142.49) 131.83,142.51 GPU1.AD22 ; v2(104.65,100.89) 104.28,100.51 CPU1.BW11 CPU1.BV11 CPU1.BU11 ; v2(104.65,100.89) 104.93,100.62 CPU1.BY11 ; v2(159.36,128.37) 159.49,128.25 159.49,127.94 VRAM2.K1 ; CPU1.G9 72.27,101.38 v2(71.89,101.01) ; R2436.2 27.05,39.42 v2(26.93,39.3) ; CPU1.R31 76.28,87.12 v2(76.2,87.12) 76.14,87.06 CPU1.P33 ; GPU1.AD15 128.85,138.44 v2(128.87,138.46) 128.87,139 ; v2(103.36,86.35) 102.78,86.35 CPU1.BT33 ; v2(87.14,89.17) 87.06,89.17 CPU1.AL29 ; v2(49.58,86.94) 50.37,86.94 C3123.2 ; v2(73.41,88.48) 73.42,88.49 CPU1.K29 ; v2(100.26,98.78) 100.38,98.78 CPU1.BP12 ; CPU1.T36 CPU1.T35 v2(77.4,85.53) CPU1.T33 ; GPU1.AG2 119.01,132.07 v2(118.92,131.98) 119.01,131.89 GPU1.AF1 ; SSD1.33 28.45,31.7 27.79,31.04 v2(27.38,31.04) 27.28,31.04 26.95,31.37 SSD1.39 ; CPU1.Y30 v2(80.75,88.52) ; ODD1.6 189.69,38.8 v2(190.29,38.2) ; C7302.2 9.25,125.55 v2(9.17,125.63) ; ODD1.9 186.4,37.3 185.52,36.42 ; PU4502.18 v2(41.18,36.07) ; v2(30.75,96.37) 30.95,96.57 WLAN1.1 ; v2(111.92,107.01) 111.8,106.89 CPU1.CM1 CPU1.CL2 ; CPU1.H9 72.91,101.07 v2(72.8,101.07) ; v2(110.42,83.29) 110.52,83.36 CPU1.CK37 CPU1.CJ36 ; v2(107.08,86.36) 107.03,86.36 106.8,86.13 CPU1.CB33 105.95,86.13 105.55,86.53 v2(105.4,86.53) ; CPU1.AW30 v2(92.61,87.9) CPU1.AW31 ; CPU1.E27 71.23,90.09 71.68,90.09 71.7,90.1 CPU1.G27 ; v2(29.85,31.01) 29.95,31.11 SSD1.27 ; CPU1.AF33 83.3,86.13 83.26,86.17 82.47,86.17 CPU1.AD33 v2(82.43,85.53) CPU1.AD35 ; CPU1.AY33 v2(92.5,85.53) CPU1.AY35 ; v2(114.18,94.06) 114.05,93.93 113.16,93.93 CPU1.CP21 CPU1.CN21 CPU1.CM21 ; v2(114.56,109.6) v2(116.28,111.33) 118.33,113.37 118.33,113.55 117.35,114.53 R1803.2 116.49,115.09 C1808.1 116.77,115.57 116.77,117.6 v2(117.3,118.14) 117.66,118.49 v2(118.88,118.49) 120.27,118.49 120.53,118.24 v2(120.53,116.65) 120.53,116.02 v2(120.53,116.02) 120.53,115.44 C1807.1 ; CPU1.F24 71.86,91.56 v2(71.86,91.55) 70.82,91.55 CPU1.D25 CPU1.C25 CPU1.B25 ; C2525.2 154.82,90.93 v2(154.87,90.88) ; CPU1.CM31 111.41,87.64 111.29,87.76 v2(111.24,87.76) ; CPU1.CP35 112.93,85.04 113.56,84.42 CPU1.CR36 ; v2(95.02,85.53) CPU1.BD35 ; SSD1.21 31.45,31.35 31.11,31.01 ; v2(47.95,96.37) WLAN1.69 ; GPU1.AC22 v2(132.39,141.95) ; v2(73.47,89.81) CPU1.K27 ; CPU1.P7 76.61,102.34 77.23,102.34 CPU1.T7 77.53,102.34 78.16,102.34 CPU1.U7 78.46,102.34 79.08,102.34 CPU1.W7 ; v2(159.54,138.39) 159.54,137.79 R7821.1 ; v2(128.24,90.22) 128.62,89.84 EC2502.2 128.93,89.92 R2063.2 ; C2613.2 C2612.2 16.92,62.41 v2(17.17,62.16) ; R7144.2 R7170.2 19.26,102.44 19.08,102.62 18.88,102.62 v2(18.85,102.64) ; v2(64,131.5) 64,131.63 63.25,132.39 63.25,133.05 62.76,133.53 PR4654.2 ; v2(90.78,89.17) CPU1.AU29 ; CPU1.AE30 v2(83.49,87.9) CPU1.AF30 ; WLAN1.77 49.78,97.53 WLAN1.75 ; CPU1.B36 CPU1.C36 70.03,84.31 CPU1.C37 ; v2(85.32,88.54) CPU1.AH30 84.71,88 84.71,87.65 CPU1.AH31 ; CPU1.B34 69.66,86.01 CPU1.C33 CPU1.E33 71.37,86.22 71.37,85.68 v2(71.44,85.61) ; ED1703.1 60.72,136.89 v4(60.76,136.86) ; v2(91.34,105) CPU1.AV3 ; v2(80.95,112.3) 80.95,113.11 ; GPU1.AF17 GPU1.AE17 v2(129.44,140.16) 129.47,140.19 GPU1.AD18 ; v2(109.93,87.17) 109.93,87.2 CPU1.CJ33 109.48,86.31 v2(109.34,86.31) CPU1.CG33 ; v2(111.84,83.26) 111.8,83.31 CPU1.CM37 ; GPU1.AE11 v2(125.39,137.21) 125.38,137.22 GPU1.AF11 ; 196.13,47.42 196.07,47.49 v2(196.07,48.31) ; GPU1.AD13 127.68,137.25 127.7,137.27 v2(127.72,137.27) ; v2(22.51,33.61) 22.45,33.55 SSD1.57 ; CPU1.BL31 99.76,87.18 v2(99.84,87.18) ; R6508.2 78.51,36.02 v2(78.06,35.56) 78,35.5 KB1.1 ; CPU1.W30 v2(78.94,88.52) CPU1.V30 ; CPU1.CN13 CPU1.CP13 ; GPU1.AF23 v2(131.84,144.81) ; WLAN1.19 v2(35.45,96.37) ; WLAN1.7 v2(32.45,96.37) ; v2(55.91,123.83) 54.99,123.83 54.66,124.16 PC4509.2 ; v2(9.07,122.43) 9.15,122.51 ED7312.1 ; CPU1.K4 74.15,104.25 CPU1.J5 ; PC8633.2 PC8618.2 113.13,152.66 v2(113.36,152.88) ; CPU1.L6 74.29,103.46 v2(74.15,103.46) ; GPU1.AD19 v2(130.62,141.33) 130.65,141.36 GPU1.AE20 GPU1.AF20 ; v2(203.2,42.79) 203.2,42.79 203.2,43.23 PC4432.2 203.64,43.67 PQ4405.4 ; WLAN1.51 v2(43.45,96.37) ; CPU1.BU7 v2(102.8,102.09) ; WLAN1.13 v2(33.95,96.37)
  BOTTOM w0.279: DM1.189 79.33,49.02 79.2,48.89 79.2,48.03 78.76,47.59 v2(78.65,47.59) ; DM2.235 167.05,51.08 167.05,49.45 166.62,49.02 v2(166.55,49.02) ; v2(150.95,48.26) 150.87,48.26 150.03,49.11 DM2.167 ; DM2.230 165.78,44.33 v2(165.78,44.34) ; DM2.90 128.78,44.34 v2(129.57,45.14) ; DM2.210 160.78,44.31 v2(160.75,44.34) ; DM2.214 161.78,44.95 161.08,45.65 v2(160.78,45.65) ; DM1.172 75.08,44.33 75.1,44.35 75.1,45.67 v2(75.95,46.53) ; v2(164.58,47.73) 164.62,47.73 166,49.11 166,50.05 166.03,50.07 DM2.231 ; DM2.47 118.03,50.3 118.05,50.28 118.05,49.45 117.57,48.97 v2(117.53,48.97) ; DM2.94 129.78,44.21 v2(129.61,44.38) ; DM1.214 85.58,45.08 85.06,45.6 v2(84.97,45.6) ; v2(32.54,44.48) 32.54,44.35 32.58,44.31 DM1.10 ; v2(122.05,48.95) 122.08,48.95 122.53,49.4 DM2.65 ; DM1.99 54.83,49.73 54.81,49.72 v2(54.81,49.62) 53.7,49.62 53.33,49.99 DM1.93 ; DM1.85 51.33,51.1 51.33,49.2 v2(51.19,49.06) ; DM2.196 v2(157.28,44.34) ; v2(105.54,45.64) 105.54,45.21 106.78,43.97 DM2.2 ; DM2.5 107.53,50 107.6,49.92 107.6,48.7 107.17,48.26 v2(107.08,48.26) 106.56,48.26 106.31,48.51 106.31,49.86 106.53,50.08 DM2.1 ; v2(108.56,47.22) 109.26,47.22 110.03,47.98 DM2.15 ; v2(42.12,45.62) 41.99,45.62 41.2,44.83 41.2,43.92 41.08,43.79 DM1.44 ; DM2.19 111.03,49.78 110.93,49.68 110.93,49.25 111.37,48.8 v2(111.46,48.8) 111.52,48.8 112.03,49.3 DM2.23 ; DM1.43 40.83,48.7 v2(41.64,47.88) ; v2(73.21,49.02) 73.54,49.02 73.83,49.31 DM1.167 ; DM1.206 83.58,43.7 83.54,43.73 v2(83.54,44.34) ; v2(43.46,44.97) 43.36,44.97 42.94,44.55 42.94,43.88 43.08,43.75 DM1.52 ; DM1.72 48.08,45.53 48.9,46.36 v2(49.25,46.36) ; DM1.247 93.83,48.9 94.76,47.96 v2(94.87,47.96) ; DM2.89 128.53,49.2 v2(128.02,48.69) 127.53,49.19 127.53,51.1 DM2.85 ; v2(30.22,44.58) 30.22,44.13 30.58,43.77 DM1.2 ; DM1.102 v2(55.58,44.44) ; v2(55.58,44.44) 56.06,44.44 56.58,43.93 DM1.106 ; v2(55.58,44.44) 55.19,44.44 54.58,43.83 DM1.98 ; v2(152.2,49.6) 152.03,49.77 DM2.175 ; v2(111.48,46.86) 111.48,45.26 111.78,44.97 DM2.22 ; v2(40.57,45.09) 40.49,45.09 40.08,44.67 DM1.40 ; v2(93.09,46.34) 92.9,46.34 91.58,45.01 DM1.238 ; DM1.47 41.83,50.13 42.08,49.87 42.08,49.42 41.66,49 v2(41.57,49) ; DM1.230 v2(89.58,44.68) ; v2(156.52,48.39) 156.64,48.39 157.53,49.27 DM2.197 ; v2(162.73,44.37) 162.78,44.33 DM2.218 ; v2(94.62,45.07) 94.59,45.07 94.08,44.55 DM1.248 ; v2(157.23,45.7) 157.03,45.7 156.28,44.94 DM2.192 ; v2(86.62,45.55) 86.58,45.5 DM1.218 ; v2(39.48,48.38) 38.83,49.04 DM1.35 ; v2(124.27,47.17) 124.27,44.47 124.28,44.46 DM2.72 ; DM1.23 35.83,49.68 35.84,49.67 35.84,49.25 35.42,48.83 v2(35.32,48.83) 35.22,48.83 34.8,49.25 34.8,49.68 34.83,49.7 DM1.19 ; DM2.201 158.53,49.11 159.26,48.37 v2(159.52,48.37) ; DM2.31 114.03,49.15 113.76,48.89 v2(113.41,48.89) 113.33,48.89 112.91,49.31 112.91,49.74 113.03,49.86 DM2.27 ; DM1.243 92.83,48.71 ; DM2.61 121.53,49.93 121.48,49.88 121.48,48.91 121.01,48.44 v2(120.91,48.44) ; DM2.78 125.78,47.05 v2(125.85,47.12) ; DM1.227 88.83,47.79 89.4,47.22 v2(89.6,47.22) 89.67,47.22 90.09,47.64 90.09,48.92 89.83,49.19 DM1.231 ; v2(37.3,49) 37.23,49 36.78,49.45 36.78,50.02 36.83,50.06 DM1.27 ; v2(123.4,47.19) 123.35,47.14 123.35,43.71 123.22,43.59 123.22,42.96 DM2.68 ; DM1.251 v2(94.83,49.28) ; v2(34.02,49.47) 33.95,49.47 33.83,49.6 DM1.15 ; v2(79.08,44.34) 79.08,42.91 DM1.188 ; v2(87.62,44.47) 87.62,44.1 87.58,44.05 DM1.222 ; DM1.77 49.33,48.09 50.9,46.52 v2(51.17,46.52) 51.27,46.52 51.69,46.1 51.69,44.08 51.58,43.96 DM1.86 ; v2(51.17,45.25) 51.12,45.25 50.58,44.7 DM1.82 ; DM1.217 86.33,49.12 v2(86.57,48.87) ; DM2.193 v2(156.53,49.66) ; v2(44.29,47.67) 43.98,47.67 42.83,48.82 DM1.51 ; v2(94.88,46.66) 94.88,46.25 95.2,45.92 95.2,43.92 95.08,43.79 DM1.252 ; v2(155.28,44.57) 155.28,44.56 DM2.188 ; DM1.9 32.33,50.25 32.41,50.17 32.41,48.38 33.47,47.32 v2(34.12,47.32) ; v2(31.78,47.47) 31.27,47.47 30.33,48.42 DM1.1 ; 46.88,46.25 45.33,47.8 DM1.61 ; 46.88,46.25 v2(46.97,46.25) ; 46.88,46.25 46.85,46.25 46.08,45.47 DM1.64 ; DM1.89 52.33,48.74 51.38,47.79 v2(51.19,47.79) 51.08,47.79 50.33,48.55 DM1.81 ; DM2.6 107.77,42.9 107.77,44 106.81,44.96 v2(106.81,45.65) ; DM2.77 125.53,48.99 124.97,48.44 v2(124.72,48.44) ; DM2.227 165.03,49.49 164.54,49 v2(164.49,49) ; v2(127.37,48.07) 127.37,48.13 126.92,48.58 126.86,48.58 126.53,48.92 DM2.81 ; 117.06,46.75 117.28,46.53 DM2.44 ; v2(32.52,45.82) 32.18,45.82 31.58,45.21 DM1.6 ; DM2.172 151.28,45.34 150.92,45.69 v2(150.87,45.69) ; v2(84.95,44.96) 84.93,44.96 84.52,44.55 84.52,44.08 84.58,44.03 DM1.210 ; v2(31.78,48.74) 31.3,49.22 31.3,49.88 31.33,49.9 DM1.5 ; DM2.223 164.03,50 163.95,49.92 163.95,48.59 163.03,47.68 v2(162.64,47.68) ; DM1.18 34.58,44.08 34.6,44.1 34.6,44.78 34.11,45.26 v2(34.06,45.26) 33.95,45.26 33.66,44.97 33.66,44.88 33.55,44.78 33.55,44.34 33.58,44.32 DM1.14 ; v2(166.55,47.7) 166.57,47.7 168,49.13 168,49.72 168.03,49.74 DM2.239 ; DM2.176 152.28,45.42 153.19,46.34 v2(153.29,46.34) ; DM2.171 151,51.07 151,49.58 v2(150.97,49.56) ; DM1.205 83.33,49.73 83.47,49.59 83.47,48.45 83.05,48.03 v2(82.95,48.03) 82.71,48.03 82.33,48.41 DM1.201 ; v2(83.57,45.65) 83.47,45.65 82.58,44.75 DM1.202 ; v2(74.49,45.19) 74.47,45.19 74.05,44.78 74.05,44.16 74.08,44.14 DM1.168 ; DM2.10 108.78,44.31 108.02,45.07 108.02,45.94 v2(107.57,46.38) ; v2(131.27,44.86) 130.78,44.36 DM2.98 ; DM1.234 90.58,45.09 89.72,45.95 v2(89.6,45.95) ; DM2.247 170.03,48.99 168.58,47.55 v2(168.51,47.55) ; DM2.52 119.28,47.54 v2(119.22,47.59) ; v2(167.8,44.34) 167.78,44.31 DM2.238 ; DM2.18 110.78,44.73 110.51,44.99 110.51,46.1 v2(110.02,46.58) ; 78.22,49.11 78.22,49.64 78.33,49.75 DM1.185 ; v2(162.77,45.65) 162.99,45.65 163.78,44.86 DM2.222 ; DM1.69 47.33,49.63 v2(47.05,49.35) ; GPU1.L2 v2(128.33,122.66) ; DM1.180 77.08,43.99 77.07,43.99 77.07,44.63 v2(77.55,45.11) ; v2(56,47.14) 55.57,47.58 55.57,49.91 55.77,50.11 55.77,51.04 DM1.103 ; v2(118.24,47.02) 118.24,45.54 118.28,45.5 DM2.48 ; v2(155.06,47.68) 154.96,47.68 154.48,48.15 154.48,49.92 154.53,49.96 DM2.185 ; DM2.69 123.53,49.03 v2(123.32,48.82) ; DM1.22 35.58,44.03 35.55,44.06 35.55,44.65 35.97,45.07 v2(36.07,45.07) ; DM2.57 120.53,51.1 120.53,49.43 120.39,49.29 120.39,48.61 120.56,48.44 ; DM1.244 v2(93.08,44.43) ; DM2.234 166.72,42.96 166.72,44.78 165.89,45.61 v2(165.79,45.61) ; v2(152.15,47.41) 152.21,47.41 153.39,48.58 153.39,49.84 153.53,49.98 DM2.181 ; DM2.86 127.78,43.96 128.68,44.87 v2(128.68,47.4) ; DM1.209 84.33,47.88 84.7,47.5 v2(84.97,47.5) 85.39,47.92 85.39,49.18 85.33,49.24 DM1.213 ; DM2.82 126.78,45.54 127.38,46.15 v2(127.38,47.42) ; 169.45,46.92 171.28,45.09 DM2.252 ; 169.45,46.92 v2(169.29,46.92) ; 169.45,46.92 170.28,46.92 171.03,47.66 DM2.251 ; v2(116.16,46.88) 116.16,44.93 116.28,44.82 DM2.40 ; DM1.65 46.33,50.17 46.25,50.09 46.25,48.93 v2(46.99,48.19) ; DM2.217 v2(162.53,49.67) ; DM2.209 160.53,49.94 160.71,49.76 v2(160.71,49.67) ; DM2.36 115.28,46.15 114.85,46.57 v2(114.85,46.92) ; v2(155.06,48.95) 155.53,49.41 DM2.189 ; DM1.175 75.83,48.84 v2(75.9,48.77) ; v2(74.83,49.66) DM1.171 ; v2(132.42,45.55) 132.42,44.29 132.78,43.94 DM2.106 ; DM2.43 117,51.08 117,48.12 117.44,47.68 117.48,47.68 ; v2(39.08,44.34) DM1.36 ; DM1.68 47.08,44.86 v2(46.97,44.97) ; GPU1.P2 126.56,124.96 v2(126,124.96) ; DM1.184 78.08,43.83 78.21,43.97 78.21,44.84 78.97,45.61 v2(79.07,45.61) ; v2(158.78,44.34) DM2.202 ; DM2.9 108.53,49.73 108.54,49.72 v2(108.54,49.35) ; v2(160.71,48.4) 160.84,48.4 161.53,49.08 DM2.213 ; DM2.180 153.28,44.36 v2(153.24,44.4) ; DM1.226 v2(88.58,44.35) ; v2(122.16,47.69) 122.19,47.69 122.63,47.25 122.63,45.07 122.28,44.71 DM2.64 ; v2(91.76,47.96) 91.76,48.1 91.83,48.16 DM1.239 ; DM1.94 53.58,44.16 v2(54,44.58) ; v2(91.78,46.66) 91.64,46.66 90.83,47.48 DM1.235 ; v2(116.02,48.4) 115.92,48.4 115.03,49.29 DM2.35 ; DM2.103 132.03,50.01 v2(130.99,48.97) 130.99,49.57 131.03,49.6 DM2.99 ; v2(76.08,44.34) DM1.176 ; v2(44.32,49.67) 44.32,49.69 44.33,49.69 DM1.57 ; DM1.193 80.33,49.61 ; DM2.102 v2(131.78,44.44) ; GPU1.Y2 v2(123.07,127.91) ; v2(49.23,44.41) 49.3,44.41 49.58,44.13 DM1.78 ; DM1.196 v2(81.08,44.34) ; DM2.51 v2(119.03,49.67) ; 150.23,44.62 150.23,46.43 150.77,46.97 v2(150.97,46.97) ; DM2.184 v2(154.28,44.34) ; DM1.48 v2(42.08,44.34) ; DM2.93 129.53,49.7 130.89,48.34 v2(130.99,48.34) 131.51,48.34 133.03,49.85 DM2.107 ; DM1.181 77.33,48.68 77.27,48.63 v2(77.27,48.07) ; DM2.205 v2(159.53,49.64) ; DM2.168 150.28,44.12 ; DM1.192 v2(80.08,44.34)
  BOTTOM w0.305: ED3502.2 19.31,47.04 19.4,46.95 19.4,46.93 19.9,46.43 v2(19.97,46.43) ; CPU1.BT25 CPU1.BR25 101.59,90.94 101.11,90.94 CPU1.BP25 ; C8213.2 165.56,149.87 v2(165.5,149.81) 165.5,149.63 VRAM3.R14 ; v2(99.69,135.46) 99.8,135.46 99.94,135.6 PU5201.19 ; v2(157.6,141.73) 158,142.13 VRAM3.F5 ; CPU1.BM9 100.02,102.05 99.97,102.1 v2(99.97,102.13) 100.12,102.13 CPU1.BN7 ; VRAM3.C4 v2(156,140.93) VRAM3.C3 ; v2(113.76,113.08) 113.67,113.08 113.21,113.54 113.21,115.11 C4034.2 ; v2(157.6,140.15) 157.58,140.15 VRAM3.E3 ; DM1.56 44.08,44.08 44.04,44.11 44.04,44.56 44.46,44.97 v2(44.55,44.97) 44.7,44.97 45.11,44.56 45.11,44.11 45.08,44.08 DM1.60 ; Q7404.1 27.24,109.06 v2(27.53,109.34) ; C8214.2 167.21,149.74 v2(167.2,149.73) VRAM3.U14 ; Q8703.4 106.06,146.37 106.22,146.53 106.22,147.5 106.39,147.67 Q8703.1 106.99,148.36 106.76,148.6 v4(106.62,148.6) ; GPU1.AC2 v2(121.31,129.7) ; CPU1.BT28 101.84,89.12 v2(101.77,89.12) ; v2(157.57,148.93) 157.2,149.31 VRAM3.E14 157.23,149.36 v2(157.23,149.86) 157.15,149.94 C8118.2 ; GPU1.B1 133.01,117.31 v2(132.64,116.94) ; 222.25,61.32 221.95,61.62 FP1.5 ; 222.25,61.32 223.07,61.32 223.45,61.7 FP1.8 ; 222.25,61.32 221.7,60.76 LCD1.43 ; CPU1.CN29 CPU1.CM29 111.48,88.87 v2(110.9,89.45) CPU1.CJ28 ; CPU1.CP35 113.14,85.35 113.29,85.35 CPU1.CR34 ; v2(111.1,99.01) 111.16,98.95 CPU1.CM13 CPU1.CN13 ; 134.28,135.51 134.94,135.51 v2(134.95,135.52) 135.69,135.52 135.7,135.51 ; CPU1.CC16 106.53,96.56 v2(106.53,96.47) 106.53,96.37 CPU1.CB18 ; v2(142.34,136.64) 142.33,136.66 GPU1.L25 ; CPU1.J18 73.16,95.46 v2(73.16,95.3) ; v2(70.71,85.33) 70.93,85.11 CPU1.E35 71.33,85.49 v2(71.44,85.61) 71.74,85.9 CPU1.F33 ; GPU1.R10 GPU1.P11 131.59,129.99 v2(132.05,129.99) 132.05,129.99 132.18,129.85 GPU1.N12 ; v2(107.18,99.84) 107.18,99.77 CPU1.CD12 ; EC6402.2 10.59,129.97 v2(9.25,129.97) ; v2(95.44,112.84) 96.19,113.59 C1711.2 96.22,114.56 R1719.2 96.22,115.48 ED1707.1 ; HDD1.17 HDD2.4 v2(164.15,39.8) ; SSD1.15 32.95,31.45 32.51,31.01 v2(30.48,31.01) ; RN1602.4 127.33,108.01 127.64,107.7 v2(127.64,107.54) 127.69,107.6 128.25,107.6 128.67,108.01 C2610.2 129.19,107.8 FC8999.2 ; WLAN1.76 29.85,96.72 30.2,96.37 v2(30.75,96.37) ; v2(219.71,54.43) 219.71,54.38 219.37,54.05 LCD1.7 ; CPU1.BT16 102.61,97.27 102.61,97.31 v2(102.64,97.34) CPU1.BU16 ; v2(110.18,102.17) 110.32,102.17 CPU1.CK7 ; v2(124.97,143.84) 125.3,144.17 ; U7602.3 134.62,101.13 134.25,101.49 v2(134.25,101.7) ; CPU1.A4 68.38,105.46 v2(68.38,105.57) CPU1.A3 ; VRAM2.K14 159.25,117.09 v2(159.25,117.02) ; R2009.2 123.29,98.86 123.68,98.48 v2(123.96,98.48) ; CPU1.BB4 94.3,104.5 CPU1.BC4 94.58,104.53 CPU1.BD4 95.23,105.18 CPU1.BE3 95.78,105.5 CPU1.BF3 ; CPU1.BB4 93.68,104.83 v2(93.87,105.02) 93.68,105.21 CPU1.BB3 ; CPU1.BB4 93.64,104.53 CPU1.BA4 CPU1.BA3 ; C8201.1 149.47,143.56 v2(148.72,144.31) ; VGABD1.6 201.95,57.82 v2(201.96,57.81) ; v2(56.09,48.72) 56.37,48.72 56.83,49.18 DM1.107 ; Q7405.4 27.04,104.72 26.98,104.65 R7429.2 26.98,103.43 27.97,102.44 v2(28.5,102.44) ; VRAM3.R4 v2(164.8,140.93) VRAM3.R3 ; CPU1.BD7 94.97,102.49 95.62,101.84 CPU1.BE8 96.28,102.06 96.31,102.06 v2(96.36,102.12) ; v2(214.61,48.36) 214.63,48.36 214.84,48.16 ED5502.2 ; CPU1.BD28 94.61,89.17 v2(94.43,89.17) ; CPU1.B2 69.35,106.06 v2(69.35,106.7) 69.63,106.7 CPU1.C1 ; R7430.2 28.42,114.48 v2(28.96,113.94) ; 120.56,48.44 v2(120.91,48.44) 121.55,47.8 121.55,46.31 121.28,46.04 DM2.60 ; v2(164.8,121.03) VRAM2.D10 164.4,120.63 v2(164.8,120.23) 164.8,120.23 VRAM2.C11 ; LCD1.4 v2(219.79,55.55) ; U6101.2 58.75,95.73 59.44,96.42 v2(60.71,96.42) ; PU4801.28 80.69,135.51 80.41,135.22 v2(80.41,134.95) ; 73.97,92.48 CPU1.J24 ; v2(105.92,36.76) 106.2,36.48 TP1.5 ; VRAM2.M10 158,121.05 157.87,121.18 v2(157.87,121.28) ; v2(88.97,105.02) 88.97,105.34 CPU1.AP3 ; v2(88.97,105.02) 89.45,104.53 CPU1.AR4 ; v2(88.97,105.02) 88.8,104.85 CPU1.AP4 88.62,104.5 88.6,104.47 ; v2(158.81,45.64) 158.87,45.64 159.78,44.74 DM2.206 ; VRAM2.C3 165.2,126.22 v2(164.8,125.83) 165.2,125.43 VRAM2.C4 ; CPU1.BY5 CPU1.CB4 ; v2(109.31,102.8) 109.1,102.8 CPU1.CG7 ; v2(12.17,119.53) 12.17,119.51 12.3,119.38 C7303.2 12.29,118.9 12.29,118.11 C7307.2 ; v2(133.51,96.21) R7606.2 134.12,95.92 133.86,95.65 U7001.5 U7001.6 134.89,95.34 U7001.7 134.92,95.06 134.89,95.04 U7001.8 ; VRAM2.N14 v2(156.8,117.03) 156.77,117 C7807.2 ; CPU1.BF4 96.08,104.53 CPU1.BE4 95.46,103.67 CPU1.BD6 ; 128.87,136.68 128.29,136.68 v2(128.27,136.7) ; GPU1.AB24 135.33,142.51 v2(135.34,142.5) ; IOBD1.1 203.3,38.06 203.52,37.84 v2(203.52,37.83) ; v2(156.8,126.63) VRAM2.N3 v2(157.6,125.83) ; 117.06,46.75 117.06,47.13 117.1,47.17 117.1,47.3 117.48,47.68 v2(117.52,47.68) ; v2(107.41,102.72) 107.64,102.72 CPU1.CE7 ; VRAM2.A14 v2(166.8,116.87) 166.83,116.84 C8217.2 ; v2(112.53,46.92) 112.53,45.01 112.78,44.76 DM2.26 ; v2(156.8,139.33) VRAM3.E1 v2(157.61,139.34) ; 196.13,47.42 196.54,47.02 PC4439.1 ; CPU1.L6 74.77,103.29 74.99,103.4 v2(75.01,103.46) ; CPU1.V4 79.04,104.52 79.17,104.85 79.22,104.9 v2(79.22,104.97) 79.22,105.05 79.19,105.07 CPU1.V3 ; GPU1.L12 133.84,128.44 v2(133.71,128.57) 133.58,128.44 GPU1.M11 GPU1.N10 ; R7932.2 149.35,122.99 v2(150.12,122.23) ; CPU1.BF33 96.46,86.32 v2(97.01,86.32) 97.35,86.32 CPU1.BH33 ; DM2.244 v2(169.28,44.34) ; v2(38.09,97.32) 38.29,97.53 WLAN1.33 ; CPU1.J12 73.16,99.23 v2(73.16,99.09) ; DM2.73 124.53,51.1 124.53,50.13 124.19,49.79 124.19,48.85 124.6,48.44 v2(124.72,48.44) ; DM2.14 109.78,44.56 109.22,45.11 v2(109.22,45.65) ; HDD1.20 HDD2.1 v2(165.65,39.8) ; VRAM3.A3 v2(154.4,140.93) ; VRAM3.A3 v2(153.6,140.93) ; VRAM3.A3 v2(154.4,140.13) ; IOBD1.4 201.8,39.09 202.26,39.55 v2(202.26,39.55) ; CPU1.AK4 86.36,104.91 v2(86.45,105) 86.36,105.09 CPU1.AK3 ; GPU1.N16 135.64,132.73 v2(135.04,132.73) 134.33,132.73 GPU1.P15 ; GPU1.B20 144.08,127.96 v2(144.13,127.91) ; C5528.2 135.16,79.1 v2(135.11,79.15) ; CPU1.AT33 90.04,86.19 90.04,86.56 CPU1.AU32 90.65,87.17 v2(90.79,87.17) 90.79,86.58 CPU1.AV33 ; CPU1.CB20 106.57,94.73 v2(106.57,94.8) 106.57,94.88 CPU1.CB19 ; R7921.2 R7924.2 v2(149.53,120.52) ; ED7302.3 ED7302.8 10.52,127.31 10.39,127.43 v2(9.86,127.43) ; 92.83,48.71 92.83,48.62 94.78,46.66 v2(94.88,46.66) ; v2(102.19,143.93) 102.14,143.93 101.63,144.43 Q8704.1 102.14,144.49 102.44,144.79 102.44,145.48 102.75,145.79 Q8704.4 ; CPU1.BD33 94.87,86.13 v2(94.55,86.45) 94.5,86.45 94.18,86.13 CPU1.BB33 ; CPU1.BR22 101.35,93.87 v2(101.35,93.95) ; CPU1.BP19 v2(101.35,95.63) 101.35,95.55 CPU1.BR19 ; C8120.2 C8123.2 163.66,138.87 VRAM3.N1 v2(163.98,139.31) ; v2(169.31,45.6) 169.46,45.6 170.28,44.79 DM2.248 ; v2(103.29,94.79) 103.29,94.72 103.22,94.63 CPU1.BU20 ; CPU1.AK33 86.21,86.39 86.66,86.85 CPU1.AL32 87.02,87.18 v2(87.08,87.18) ; C8112.2 164.98,116.77 v2(165.08,116.88) 165.08,116.89 165.2,117 VRAM2.C14 ; PC4440.1 201.03,43.23 200.69,43.23 v2(200.59,43.13) ; v2(35.11,106.25) 35.2,106.16 WLAN1.18 ; CPU1.BV33 103.61,86.35 v2(103.36,86.35) ; 132.87,135.51 v2(132.28,135.51) 131.45,135.51 ; CPU1.B5 69.72,103.87 v2(70.18,103.87) 70.18,104.31 CPU1.C4 ; PQ4415.4 206.82,42.86 206.71,42.75 v2(206.71,42.22) 206.84,42.22 207.01,42.04 208.35,42.04 208.58,41.81 PQ4415.1 ; WLAN1.45 41.95,98.54 41.58,98.91 40.82,98.91 40.45,98.54 WLAN1.39 40.45,96.44 v2(40.33,96.32) ; R8209.1 150.12,145.85 v2(149.98,145.7) ; v2(75.96,103.44) 75.9,103.38 75.55,103.18 CPU1.N6 ; VRAM3.K2 VRAM3.K1 161.2,138.41 161.25,138.36 v2(161.25,138.36) ; VRAM2.F10 v2(162.4,121.03) VRAM2.G10 ; CPU1.BV31 v2(104.46,87.89) ; v2(74.41,87.82) 74.24,87.82 CPU1.K31 ; CPU1.BC25 v2(93.97,91.75) ; CPU1.AB3 CPU1.AB4 CPU1.AC5 82.39,104.18 v2(82.49,104.18) ; v2(159.2,117.83) VRAM2.K13 v2(160,118.63) ; PR4497.1 13.34,125.27 v2(13.54,125.48) ; v2(73.47,89.81) 73.3,89.81 CPU1.H27 ; CPU1.CD11 107.46,100.33 106.95,100.33 CPU1.CC11 CPU1.CB11 CPU1.CA11 CPU1.BY11 ; R1717.2 23.69,59.57 23.72,59.61 v2(23.81,59.61) ; R8110.1 151.46,120.7 v2(151.13,120.38) ; LCD1.1 LCD1.41 ; GPU1.AF8 123.04,135.45 v2(123.04,134.88) ; VRAM3.H1 159.6,138.46 159.54,138.4 v2(159.54,138.39) ; v2(158.4,142.53) VRAM3.G5 ; VRAM3.T10 v2(166.4,145.73) ; v2(74.2,112.14) 73.36,112.14 R1517.2 ; GPU1.U12 129.46,132.68 v2(129.36,132.59) 129.27,132.68 GPU1.V11 ; FC8922.2 FC8923.2 98.17,139.88 PC5001.2 ; v2(96.47,91.95) 96.47,91.95 96.71,91.71 CPU1.BG25 ; GPU1.K13 v2(136.11,128.03) ; v2(68.76,147.7) 69.62,147.7 69.95,147.37 PC4601.2 ; EC8999.2 41.69,30.44 41.24,30.89 FC8962.2 40.42,30.89 C6306.2 ; CPU1.CH31 109.87,87.2 109.91,87.2 v2(109.93,87.17) ; v2(191.21,37.46) 191.04,37.46 v2(190.29,38.2) ; C8605.2 C8608.2 160.38,110.49 v2(160.18,110.29) ; C8105.2 155.12,116.95 v2(155.2,117.03) VRAM2.R14 ; CPU1.F15 v2(71.2,97.21) ; VRAM3.G10 v2(159.2,146.53) ; v2(114.33,95.23) 114.19,95.09 113.31,95.09 CPU1.CP19 ; v2(162.83,145.59) 162.82,145.61 162.82,146.1 162.8,146.12 VRAM3.M10 ; CPU1.BE10 v2(95.86,100.27) ; v2(155.2,126.63) VRAM2.R3 155.2,125.83 v2(155.2,125.79) 155.56,125.43 VRAM2.R4 ; v2(23.81,59.61) 23.81,59.33 23.98,59.16 R2426.1 ; v2(23.81,59.61) 23.81,59.75 23.95,59.89 ED1702.1 ; HDD1.14 HDD2.7 v2(162.65,39.8) ; CPU1.CF28 108.95,89.84 v2(108.99,89.84) ; GPU1.E22 143.51,131.37 v2(142.97,131.37) ; v2(206.33,53.8) 206.15,53.8 205.81,54.14 205.81,54.15 205.65,54.31 205.64,54.31 205.51,54.44 PC4416.1 ; VGABD1.20 194.49,58.39 v2(194.49,57.81) ; v2(163.2,148.93) VRAM3.N14 v2(164,148.93) ; v2(77.28,46.65) 77.4,46.65 78.1,47.35 78.1,49 78.22,49.11 ; v2(26.77,72.9) 26.37,72.49 26.37,72.39 C2428.2 ; v2(39.63,49.67) 39.83,49.86 DM1.39 ; v2(153.58,147.31) VRAM3.A12 ; VRAM3.A12 v2(154.4,148.13) ; VRAM3.A12 v2(154.42,147.31) ; VRAM3.A12 v2(153.6,148.13) ; v2(132.36,100.96) 132.36,100.96 132.36,101.07 Q7907.1 131.42,102.52 131.09,102.85 130.45,102.85 130.12,103.18 Q7907.4 ; VRAM3.L10 162,145.79 161.91,145.71 v2(161.91,145.59) ; v2(154.4,142.53) VRAM3.B5 ; R2448.2 23.09,63.12 22.92,63.29 ; Q8705.4 105.86,140.99 ; v2(200.42,57.81) 200.45,57.84 VGABD1.9 ; v2(102.52,30.2) 102.52,31.3 TP1.10 101.52,33.31 100.99,33.83 C6506.2 ; GPU1.AA7 GPU1.AB7 124.2,132.58 123.6,131.98 GPU1.AC5 ; v2(166.41,142.54) VRAM3.T5 ; v2(154,138.37) VRAM3.A1 153.93,138.93 v2(153.54,139.32) ; VRAM2.N1 v2(157.2,128.36) 157.03,128.54 157.03,128.58 156.9,128.71 C8212.2 ; GPU1.L10 v2(133.56,127.03) GPU1.K11 ; DM1.90 52.58,44.04 53.12,44.58 v2(54,44.58) ; C801.2 90.37,117.04 ED301.3 ; v2(163.17,126.63) 163.2,126.63 163.6,126.23 VRAM2.E3 163.99,125.84 v2(164,125.84) ; CPU1.R30 76.75,88.15 v2(77.09,88.49) ; v2(28.68,74.93) 28.13,75.48 R2454.2 ; v2(102.31,41.45) 102.59,41.18 Q501.S Q502.S ; CPU1.CC20 107.21,94.72 v2(107.21,94.78) 107.53,94.46 CPU1.CD20 ; RN1602.3 v2(127.59,108.66) 127.74,108.66 C2614.2 ; C8209.2 C8117.2 165.18,127.85 VRAM2.C1 v2(165.6,127.43) ; v2(107.08,86.36) 107.13,86.41 107.32,86.41 CPU1.CE33 ; VRAM3.U3 v2(167.2,140.93) ; PWR1.5 213.45,57.12 213.39,57.18 213.39,57.38 v2(213.26,57.51) ; CPU1.CA15 v2(105.27,97.31) ; CPU1.BH35 v2(97.53,85.53) CPU1.BH33 ; EC2503.2 EC2501.2 132.69,78 132.82,77.88 v2(132.83,77.88) ; GPU1.K15 137.84,129.85 v2(137.93,129.77) ; GPU1.L14 135.04,129.85 v2(135,129.9) 134.96,129.85 GPU1.M13 ; PC4421.2 196.22,52.18 v2(195.86,51.82) ; PC4631.2 73.31,145.73 v2(73.31,146.13) ; ED1217.3 55.83,39.32 55.83,39.3 v2(56.3,39.3) ; VRAM3.C12 v2(156,148.13) ; GPU1.U18 134.27,136.91 v2(133.59,136.91) 133.57,136.93 GPU1.V17 ; GPU1.R16 134.23,134.15 v2(133.65,134.15) 133.6,134.1 GPU1.T15 ; v2(119.22,47.59) 120.13,47.59 120.48,47.24 120.48,46.59 120.28,46.38 DM2.56 ; v2(131.11,112.61) R7915.2 132.11,112.5 R7939.2 ; C8109.2 C8223.2 155.37,149.97 v2(155.47,149.87) 155.6,149.74 VRAM3.C14 ; VRAM2.L5 158.8,124.26 v2(158.64,124.1) ; Q7404.4 v2(25.62,111.65) 25.8,111.65 R7431.2 ; v2(75.72,154.97) 75.33,154.57 PR4628.2 PR4629.2 ; v2(160.8,118.63) VRAM2.H13 VRAM2.H14 v2(161.2,116.9) 161.47,116.63 R8113.2 ; CPU1.BY25 v2(104.6,91.45) ; CPU1.F4 71.81,105.41 CPU1.F3 CPU1.F2 71.71,106.69 v2(71.76,106.73) ; VRAM3.U12 v2(166.4,148.13) ; R2108.2 120.69,93.71 v2(120.7,93.7) ; v2(88.51,91.72) CPU1.AN25 ; v2(99.85,89.15) 99.85,89.16 99.84,89.21 CPU1.BL28 ; GPU1.R12 130.86,131.27 v2(130.86,131.27) 130.86,131.27 GPU1.T11 GPU1.U10 ; VRAM2.R11 v2(156,120.23) VRAM2.P10 ; DM2.39 v2(116.03,49.67) ; R8204.2 R8213.2 159.18,151.27 159.19,151.27 v2(159.6,149.86) VRAM3.H14 159.72,149.21 159.72,148.65 VRAM3.H13 ; v2(4.07,39.93) 4.07,39.14 4.36,38.85 USB2.11 7.57,38.85 ; VRAM3.N12 v2(164,148.13) ; v2(22.36,63.2) 22.45,63.29 22.92,63.29 ; VRAM3.C1 v2(155.6,138.37) ; CPU1.B36 69.55,84.02 CPU1.B37 CPU1.A36 68.52,84.31 v2(68.15,84.68) ; 80.33,49.61 80.33,48.76 79.86,48.29 79.86,47.35 v2(80.27,46.94) ; v2(167.31,124.21) 167.24,124.13 166.49,124.13 v2(166.41,124.21) 166,124.62 VRAM2.B5 166.01,124.63 v2(166.4,125.02) ; CPU1.D8 70.94,102.24 70.94,102.9 70.87,102.97 CPU1.D6 71.12,103.3 v2(71.38,103.56) 70.98,103.95 CPU1.D5 ; v2(30.69,77.78) 30.69,77.45 30.89,77.24 32.74,77.24 v2(33.3,77.8) ; U4007.3 87.43,40.85 v2(86.82,41.45) ; v2(164,118.64) 163.6,119.03 VRAM2.E12 v2(163.2,118.63) ; CPU1.BH33 97.71,86.13 v2(98.08,86.5) 97.97,86.5 CPU1.BH32 ; VRAM3.A14 v2(154,149.89) 153.85,150.04 C8211.2 153.85,151.23 C8110.2 ; C8106.2 153.6,115.95 v2(153.6,117.03) VRAM2.U14 ; JUSB1.18 8.53,124.99 v2(9.17,125.63) ; VRAM2.B10 166,121.19 v2(166,121.2) ; v2(88.09,147.14) 87.79,147.14 86.87,148.06 86.87,149.81 PR4621.1 PR4608.1 ; C802.2 79.53,114.53 FC8981.2 v1(80.88,113.18) 80.95,113.11 ; VRAM2.R12 v2(156,118.63) ; CPU1.AN31 88.83,87.83 v2(88.93,87.83) 88.61,88.15 CPU1.AN30 ; VGABD1.12 v2(198.95,57.81) ; v2(113.41,47.55) 113.41,45.64 113.78,45.28 DM2.30 ; VRAM2.T5 v2(154.8,124.1) ; CPU1.BP33 101.36,86.19 101.36,86.75 CPU1.BP32 101.59,87.17 v2(101.77,87.17) ; PQ4416.4 208.17,45.91 208.74,46.48 208.74,46.75 v2(208.73,46.76) ; CPU1.CF11 v2(108.04,100.11) ; CPU1.K24 74.13,91.88 v2(73.79,91.54) 73.79,91.41 CPU1.K25 ; C5531.2 138.71,92.33 v2(138.84,92.46) ; PC5124.2 v2(100.55,37.62) ; 58.6,118.59 57.87,117.87 C4004.2 ; X7901.4 156.06,111.69 v2(155.07,111.69) 154.96,111.8 C7907.1 ; v2(80.95,112.3) 81.03,112.22 R316.2 ; v2(83.37,102.77) 83.21,102.77 CPU1.AE7 ; EC8940.2 60,91.77 61.86,89.91 v2(61.86,89.11) ; CPU1.CB25 106.56,91.36 v2(106.56,91.44) CPU1.CC25 ; v2(85.17,104.14) 85.13,104.14 CPU1.AG5 84.7,103.79 83.99,104.5 CPU1.AF4 CPU1.AF3 ; C2409.2 22.92,63.29 ; GPU1.T13 132.14,132.68 v2(132.15,132.67) 132.16,132.68 GPU1.R14 ; FC8984.2 129.04,102.74 v2(129.47,102.31) 129.19,102.03 Q401.1 ; CPU1.BL30 99.73,88.39 99.8,88.39 99.84,88.44 v2(99.86,88.44) 99.81,88.49 99.78,88.61 CPU1.BL29 ; VRAM2.G5 v2(162.4,124.23) VRAM2.F5 v2(163.2,125.03) ; v2(167.46,40.44) 168.05,39.85 HDD1.24 ; R2007.2 v2(130.15,94.77) ; v2(127.57,116.03) 127.18,115.65 R7911.2 126.8,115.75 R7926.2 ; CPU1.F18 71.18,95.44 v2(71.18,95.31) ; DM1.197 81.33,46.34 v2(81.61,46.05) ; CPU1.CD25 v2(107.2,91.45) ; U7302.3 135.95,99.75 135.8,99.91 v2(135.23,99.91) ; GPU1.P17 136.37,134.1 v2(136.38,134.08) 136.4,134.1 GPU1.N18 ; v2(15.66,95.66) ED5701.3 ED5701.8 ; DM2.243 169.03,49.76 169.06,49.73 169.06,49.28 168.64,48.87 v2(168.5,48.87) ; CPU1.B12 69.9,99.22 v2(69.9,99.07) ; CPU1.B18 69.26,95.3 v2(69.25,95.3) ; PU4802.28 74.05,135.46 73.62,135.88 v2(73.62,136.04) ; VRAM3.C11 v2(156,146.53) VRAM3.D10 ; CPU1.CJ11 v2(109.97,100.06) ; CPU1.BW24 103.96,91.55 v2(103.96,91.42) ; v2(163.21,140.93) 163.6,140.54 VRAM3.N3 ; C8111.2 163.6,115.9 v2(163.6,116.9) VRAM2.E14 ; U2502.2 156.42,96.62 156.72,96.32 v2(158.25,96.32) ; CPU1.AG10 v2(84.77,100.2) ; v2(14.05,38.79) 14.21,38.94 MESW1.7 ; DCIN1.9 15.9,125.53 v2(16.34,125.1) ; CPU1.CN25 CPU1.CM25 111.24,91.75 v2(110.57,91.75) ; v2(90.31,100.26) 90.32,100.27 CPU1.AU10 ; DM1.261 29.9,61.34 29.62,61.62 v2(29.62,61.68) ; GPU1.A26 148.31,131.24 v2(148.72,131.24) ; GPU1.E8 v2(135.37,122.62) ; CPU1.CD24 107.75,91.64 v2(107.98,91.64) ; 150.23,44.62 v2(150.04,44.43) 150.04,44.35 150.28,44.12 ; CPU1.AC10 v2(82,100.23) ; CPU1.AN28 88.79,89.16 v2(88.93,89.16) 88.56,88.8 CPU1.AN29 ; CPU1.BA6 v2(93.54,103.44) ; v2(197.49,57.48) 197.49,57.99 197.45,58.03 VGABD1.15 ; v2(39.15,46.3) 38.58,46.3 37.58,45.29 v2(37.58,44.5) DM1.30 ; PQ4405.1 205.67,45.25 205.67,46.36 206.09,46.79 206.24,46.79 v2(206.25,46.8) 206.64,46.8 PQ4416.1 ; v2(98.08,89.17) 98.25,89.17 CPU1.BK28 ; v2(160,140.12) 159.61,139.73 VRAM3.H2 ; CPU1.BP15 v2(101.35,97.32) CPU1.BR16 ; VRAM3.F10 v2(157.6,145.73) ; VRAM3.E12 v2(156.82,148.11) ; 145.81,133.14 145.28,133.14 ; v2(43.99,86.54) 43.18,86.54 R3102.2 ; VRAM3.M5 v2(163.2,141.73) ; v2(112.57,79.55) 113.1,83.39 CPU1.CP37 CPU1.CR36 ; v2(156.03,127.44) 155.99,127.44 VRAM2.R1 v2(155.6,128.39) 155.37,128.61 C8115.2 ; v2(157.94,107.85) 155.65,107.85 155.28,108.23 C7908.1 ; VRAM4.C13 v2(165.6,148.93) ; CPU1.P10 76.77,100.61 v2(76.94,100.61) ; R7910.2 157.24,113.56 v2(157.23,113.56) ; USB2.10 7.55,23.15 ; CPU1.CF19 107.95,94.98 v2(107.95,94.87) ; CPU1.J5 74.07,103.46 v2(74.15,103.46) 74.11,103.35 CPU1.J6 ; R5764.2 16.94,107.06 v2(16.49,106.61) ; VRAM2.N12 v2(156.8,118.63) ; v2(52.25,114.53) 52.53,114.25 C5863.2 52.53,113.18 R5816.1 ; CPU1.AV25 v2(91.24,91.77) ; CPU1.CA22 v2(105.25,93.97) 104.93,93.64 CPU1.BY22 ; R7929.2 134.85,113.75 134.85,115.22 134.78,115.29 134.78,115.42 134.14,116.05 v2(134.14,116.84) ; R7908.2 129.69,114.5 v2(129.47,114.28) ; CPU1.AV6 v2(91.71,103.39) ; VRAM2.H2 VRAM2.H1 161.2,128.22 v2(161.07,128.35) ; v2(48.26,49.58) 48.33,49.64 48.33,51.1 DM1.73 ; EC8977.2 EC8950.2 51.03,97.82 WLAN1.77 51.24,98.99 52.7,98.99 v2(53.04,98.65) ; IOBD1.10 v2(198.8,39.45) ; CPU1.BU24 v2(103.3,92.28) CPU1.BU23 ; VRAM3.U1 166.96,138.77 v2(166.96,138.25) C8205.2 167.08,137.34 C8122.2 ; DM2.226 v2(164.78,44.38) ; GPU1.N14 133.63,131.27 v2(133.6,131.3) 133.57,131.27 GPU1.P13 ; CPU1.BT14 v2(102.65,98.16) CPU1.BT15 ; ED6401.3 210.67,52.6 U5501.2 ; v2(154.4,127.43) VRAM2.U1 153.72,128.11 C8107.2 ; CPU1.B15 v2(69.23,97.2) ; CPU1.CB24 v2(105.9,91.45) ; CPU1.BA10 v2(93.09,100.38) ; VRAM2.L10 v2(158.8,121.27) ; VRAM3.R1 165.31,138.82 v2(165.31,138.38) C8124.2 C8204.2 ; ED9202.2 209.22,55.45 209.91,56.14 C6401.1 209.91,56.82 v2(209.55,57.18) ; v2(105.4,86.53) 105.4,86.45 CPU1.BY33 ; VRAM2.A1 v2(167.37,127.83) 167.37,128.34 166.96,128.75 C8119.2 C8206.2 ; CPU1.CM9 CPU1.CN9 ; GPU1.L16 136.5,131.27 v2(136.48,131.29) 136.45,131.27 GPU1.M15 ; v2(140.63,134.96) GPU1.L23 ; v2(157.25,93.53) 157.6,93.88 158.44,93.88 PQ4402.S ; CPU1.F24 71.2,92.31 CPU1.E23 ; GPU1.U14 131.43,134.08 v2(130.83,134.08) 130.82,134.1 GPU1.V13 ; CPU1.Y7 79.92,102.72 v2(79.7,102.72) 79.46,102.72 CPU1.W7 ; CPU1.E9 v2(71,101.04) CPU1.D9 ; VRAM3.P10 v2(164.8,146.53) VRAM3.R11 ; BIOS1.4 132.75,87.12 v2(132.41,86.78) ; VRAM2.K1 159.49,127.72 159.49,127.14 VRAM2.K2 ; CPU1.F12 71.27,99.16 v2(71.2,99.09) ; VRAM2.A12 166.8,119.04 v2(166.41,119.43) ; VRAM3.L5 v2(162.4,141.73) ; CPU1.J15 73.16,97.35 v2(73.16,97.21) ; VRAM3.K13 v2(161.58,148.91) 161.2,149.28 VRAM3.K14 v2(161.58,149.71) ; GPU1.B5 v2(135.85,119.71) ; GPU1.AF5 v2(121.31,134.25) ; CPU1.BY18 104.61,95.74 v2(104.61,95.63) 104.62,95.63 CPU1.BY19 ; PR5203.2 100.92,141.66 v2(100.79,141.78) PC5215.2 ; IOBD1.7 200.3,38.14 v2(199.96,37.8) ; VRAM3.R12 v2(164.8,148.13) ; CPU1.D1 v2(70.49,107.05) ; CPU1.BL32 99.44,86.5 v2(99.59,86.36) 99.02,86.36 CPU1.BK33 ; CPU1.W10 79.23,100.43 v2(79.38,100.28) ; CPU1.BT5 103.1,104.19 103.41,104.5 CPU1.BV4 CPU1.BV3 ; v2(135.07,151.94) 135.19,151.83 C7612.2 ; VRAM2.U12 v2(154.4,119.43) ; CPU1.BK10 v2(98.63,100.41) ; VRAM2.C12 v2(164.8,118.63) ; VRAM2.A3 v2(167.36,126.23) ; VRAM2.E1 163.6,128.32 163.63,128.35 v2(163.63,128.37) 163.58,128.42 C8215.2 C8216.2 ; CPU1.CE35 CPU1.CE36 ; CPU1.BT36 CPU1.BT35 102.57,85.52 v2(102.54,85.55) 102.57,85.57 CPU1.BT33 ; VRAM2.U3 v2(153.6,126.63) ; VRAM1.C13 v2(155.2,117.83) ; VRAM2.M5 v2(157.6,125.03) ; VRAM2.T10 v2(154.8,121.27) ; CPU1.K30 74.26,88.45 74.41,88.45 v2(74.43,88.47) ; CPU1.CA25 v2(105.25,91.45) ; R7614.2 139.7,101.65 ; v2(124.74,129.57) 124.74,130.16 GPU1.Y5 ; CPU1.AM10 v2(87.54,100.38) ; PR4614.2 83.8,152.5 84.33,153.04 84.86,153.04 ; CPU1.CC14 106.88,98.51 v2(107.22,98.17) CPU1.CD14 107.61,98.5 CPU1.CF14
  BOTTOM w0.35: v2(144.1,134.89) 144.08,134.9 GPU1.H25 ; v2(138.28,137.27) 138.88,137.27 GPU1.P23
  BOTTOM w0.356: v2(129.55,121.36) 129.55,121.36 129.97,121.36 GPU1.H2 ; GPU1.E17 140.63,129.02 v2(140.62,129.03) ; v2(125.97,128.42) 126.51,128.42 GPU1.U5 ; v2(142.42,133.22) 142.42,133.74 GPU1.H23 ; GPU1.P5 128.24,126.7 v2(127.73,126.7) ; v2(139.45,126.67) GPU1.E14 ; v2(131.8,140.17) 132.35,140.17 GPU1.AB20 ; GPU1.AC26 135.32,144.23 v2(135.32,143.66) ; GPU1.E11 137.12,124.4 137.14,124.38 v2(137.14,124.36) ; v2(137.09,141.92) 137.09,142.46 GPU1.Y26 ; GPU1.H5 131.22,123.16 v2(131.21,123.16) ; GPU1.E5 v2(134.12,121.44) ; v2(124.24,126.72) 124.81,126.72 GPU1.U2 ; v2(142.38,129.61) GPU1.E20 ; v2(140.59,138.4) 140.59,138.96 GPU1.P26 ; v2(139.39,141.6) 138.82,141.03 GPU1.U26 ; GPU1.L5 v2(129.43,124.92) ; GPU1.A2 v2(134.14,116.84)
  BOTTOM w0.381: 58.6,118.59 v2(58.65,118.64) ; Q8101.S 159.97,114.02 160.51,113.49 v2(160.51,113.41) ; ED5702.3 ED5702.8 v2(15.69,98.71)
  BOTTOM w0.4: GPU1.B23 146.41,130.24 v2(146.45,130.28) ; v2(141.75,126.73) 141.75,126.73 GPU1.B17 v2(142.33,126.16) ; 140,124.98 140.57,124.98 GPU1.B14 ; v2(148.72,132.51) 148.69,132.54 GPU1.B27 ; GPU1.U23 137.12,139.03 v2(136.53,139.03) ; v2(135.94,140.77) 135.38,140.77 GPU1.Y23
  BOTTOM w0.457: GPU1.M17 v2(137.81,132.68) GPU1.L18 v2(138.52,132.06) GPU1.K17
  BOTTOM w0.508: 4.57,117.63 JUSB1.14 ; JUSB1.14 5.91,116.79 ; JUSB1.14 7.24,117.63 ; v2(217.43,65.03) 217.88,65.03 218.25,65.39 FP1.10 ; JUSB1.21 5.91,130.61 ; JUSB1.21 4.57,129.77 ; JUSB1.21 7.24,129.77 ; USB1.11 5.44,64.95 ; v2(67.64,41.56) 67.87,41.33 PC5303.2 ; 109.73,134.04 H5.1 112.87,137.18 ; v2(15.01,114.43) 14.15,113.56 R5782.2 13.29,113.43 C7305.2 ; 7.15,128.18 JUSB1.20 8.24,128.96 ; USB1.10 6.2,47.8 7.37,46.64 ; PC8617.2 114.05,152.07 ; 3.61,117.2 3.18,117.63 JUSB1.13 ; PC8614.2 122.1,144.97 C7623.2 124.59,144.83 v2(124.84,144.58) ; v2(157.94,107.85) X7901.2 158.93,109.97 v2(158.93,110.31) v2(158.93,111.18) ; PC4409.2 PC4412.2 178.67,58.47 v2(178.19,58.47) 176.28,58.47 175.75,59 DM2.262 ; v2(109.48,154.79) PR8626.2 109.45,154.1 PR8632.1 R8604.2 107.95,154.74 v2(107.98,154.76) ; FAN1.2 v2(160.07,87.7) ; v2(203.46,60.45) 203.46,62 203.6,62.15 VGABD1.22 ; 2.04,130.61 JUSB1.22 3.37,129.77 ; v2(147.07,32.67) 148.17,33.77 BATT1.11 ; v2(151.49,114.45) 151.41,114.53 151.41,116.34 C8004.2 149.73,117.49 149.37,117.13 C8035.2 ; v2(192.84,65) 192.84,62.16 192.55,61.87 VGABD1.24 191.49,61.87 190.36,61.87 189.99,61.5 PC4404.2 ; RJ1.12 3.2,68.25 4.22,67.24 ; U5702.1 v2(15.07,101.01) ; 13.03,106.6 HDMI1.21 11.7,105.61 ; USB1.13 13.68,62.05 ; USB1.13 12.24,61.16 ; USB1.13 12.24,62.94 ; ED301.3 v2(90.15,116) 89.64,115.5 R1714.2 ; Q6501.S v2(106.45,40.63) ; RJ1.9 11.88,85.05 ; RJ1.9 10.55,85.89 ; RJ1.9 9.22,85.05 ; 12.24,36.51 USB2.13 12.24,38.29 ; USB1.12 13.68,49.25 ; USB1.12 12.24,50.52 ; USB1.12 12.24,48.36 ; v2(88.98,112.19) 88.84,112.06 R601.2 ; R808.2 67.6,109.2 v2(67.55,109.2) ; v2(78.28,31.48) 78.28,31.48 KB1.31 ; USB1.4 13.14,50.95 ; 8.24,118.44 JUSB1.15 7.15,119.23 ; VGABD1.21 206.58,61.07 v2(206.58,62.92) ; v2(189.87,42.8) 189.67,43 ODD1.17 ; 3.5,89.21 HDMI1.22 4.83,90.2 ; JUSB1.B12 6.71,118.95 v2(6.66,118.9) ; 9.22,68.25 RJ1.10 ; RJ1.10 11.88,68.25 ; RJ1.10 10.55,67.41 ; C1223.2 97.82,40.41 v2(97.82,39.63) ; v2(202.07,41.12) 202.06,41.12 202.02,41.16 ED6601.2 ; C2503.2 162.87,90.16 FAN1.5 v2(165.48,90) ; 4.83,108.5 HDMI1.23 3.5,109.49 ; v2(220.32,61.06) 221.24,60.15 LCD1.43 ; 37.01,131.05 HS3.1 40.2,134.24 ; v2(124.84,39.45) 125.22,39.45 ED4306.1 127.18,40.01 127.61,40.01 ED1302.3 ; PWR1.7 209.07,60.48 v2(208.61,60.48) ; R1518.2 v2(66.17,111.43) ; 11.7,91.11 HDMI1.20 ; HDMI1.20 13.03,92.1 ; HDMI1.20 11.7,93.09 ; v2(195.02,65) 195.02,63.53 VGABD1.23 ; FC8909.2 17.71,37.82 C3518.2 17.78,38.36 17.78,40.18 17.53,40.44 U3502.2 15.98,40.44 v2(15.93,40.49) ; SSD1.76 38.46,30.89 C6307.2 C6306.2 ; C8202.2 161.65,151.97 162.08,152.4 ; PC4410.2 176.83,35.97 v2(176.47,36.32) ; USB2.4 13.14,27.09 12.75,26.71 12.75,26.6 12.24,26.08 USB2.12 12.24,23.71 ; v2(202.3,55.6) 201.79,55.6 EC6405.2 201.67,54.86 PC4417.1 ; FP1.9 v2(225.94,65.8) ; v2(64,131.5) 64,131.26 63.71,130.97 PC4507.2 ; JUSB1.B1 6.71,128.4 v2(6.66,128.45) ; v2(140.64,40.62) EC4308.2 ; PC4426.1 196.13,43.67 v2(196.88,42.92) ; PC4403.2 194.77,57.07 194.49,57.35 v2(194.49,57.81) ; PWR1.8 215.95,59.8 216.82,58.93 v2(218.64,58.93) ; 2.75,85.89 RJ1.11 4.08,85.05 ; Q6503.S 96.84,27.16 ; v2(149.56,115.03) 149.32,115.26 R7902.2 ; v2(191.21,37.46) 192.1,36.57 IOBD1.22 ; PC4603.1 69.5,151.97
  vias: v1(3.84,5.26) v1(9.73,114.3) v1(14.86,94.16) v1(17.86,55.6) v1(22.08,106.4) v1(22.1,105.18) v1(34.93,2.11) v1(39.93,26.65) v1(43.49,79.96) v1(44.73,90.45) v1(46.66,84.05) v1(48.19,110.24) v1(60.91,122.43) v1(62.49,118.8) v1(63.73,101.12) v1(66.22,151.39) v1(66.58,151.16) v1(71.89,133.4) v1(75.34,139.19) v1(75.54,119.56) v1(76.94,132.97) v1(78.92,150.55) v1(83.92,132.97) v1(88.5,124.92) v1(89.06,139.07) v1(89.08,121.54) v1(89.13,119.56) v1(90.83,139.6) v1(96.19,137.39) v1(96.37,153.47) v1(105.26,133.63) v1(110.72,37.49) v1(112.12,32.18) v1(115.85,151.21) v1(118.7,140.18) v1(120.09,151.33) v1(123.52,120.22) v1(127.03,148.49) v1(142.14,106.55) v1(143.11,104.24) v1(151.77,82.04) v1(152.1,82.4) v1(153.72,99.04) v1(154.1,102.87) v1(154.38,113.01) v1(160.96,105.31) v1(162.13,152.48) v1(162.56,81.54) v1(167.11,113.88) v1(167.39,135.51) v1(203.69,49.48) v1(218.01,35.1) v2(1.68,7.6) v2(1.69,5.63) v2(1.88,1.4) v2(2.9,4.37) v2(3.13,116.74) v2(3.18,110.03) v2(3.18,88.27) v2(3.22,66.78) v2(3.2,2.08) v2(3.76,64.82) v2(3.97,129.59) v2(3.97,117.81) v2(4.07,136.78) v2(4.06,46.74) v2(4.3,3.28) v2(5.01,85.81) v2(5.08,1.04) v2(5.29,5.26) v2(5.41,90.5) v2(6.05,3.76) v2(6.15,108.19) v2(6.35,67.09) v2(8.03,1.02) v2(8.18,38.94) v2(8.26,90.5) v2(8.3,84.94) v2(8.33,68.36) v2(8.33,47.73) v2(9.07,63.6) v2(9.17,23.06) v2(9.53,112.17) v2(9.66,114.86) v2(9.71,108) v2(10.04,104.98) v2(10.04,93.75) v2(10.77,131.85) v2(11.17,39.17) v2(11.41,1.02) v2(12.65,84.94) v2(12.87,68.69) v2(13.62,104.24) v2(14.96,118.92) v2(15.37,127.52) v2(15.55,123.32) v2(15.46,122.15) v2(15.48,121.02) v2(15.57,116.26) v2(15.67,116.99) v2(15.76,49.26) v2(16.36,130.48) v2(17.02,55.86) v2(17.15,1.04) v2(19.64,130.48) v2(21.19,83.75) v2(21.74,84.1) v2(21.74,83.41) v2(21.97,107.06) v2(22,105.79) v2(22,104.57) v2(22.51,130.48) v2(22.48,35.51) v2(23.42,47.45) v2(23.37,45.49) v2(23.37,43.46) v2(23.4,41.48) v2(24.05,91.12) v2(24.9,130.46) v2(24.9,39.3) v2(24.9,37.39) v2(24.97,123.09) v2(25.28,54.56) v2(25.66,13.77) v2(26.04,119.32) v2(26.04,117.4) v2(26.29,13.77) v2(26.93,37.39) v2(26.93,15.04) v2(26.93,14.4) v2(26.93,13.77) v2(27.18,131.12) v2(27.56,13.77) v2(27.72,132.92) v2(28.07,44.3) v2(28.2,13.77) v2(28.35,107.24) v2(28.67,42.8) v2(28.81,104.24) v2(28.94,112.13) v2(28.86,105.51) v2(29.98,41.5) v2(29.98,38.61) v2(30.51,3.28) v2(30.69,116.28) v2(30.76,94.41) v2(30.76,38.18) v2(31.04,134.47) v2(31.14,39.98) v2(31.25,106.23) v2(31.78,111.81) v2(32.01,106.23) v2(32.11,1.04) v2(32.21,40.06) v2(32.18,38.13) v2(32.44,94.46) v2(33.04,118.39) v2(33.63,134.47) v2(33.71,38.36) v2(33.91,94.46) v2(34.34,1.02) v2(35.23,7.34) v2(35.33,47.45) v2(35.36,4.47) v2(35.46,94.46) v2(36.07,134.47) v2(36.16,18.03) v2(36.17,16.08) v2(36.17,14) v2(36.17,12.9) v2(36.17,5.41) v2(36.17,2.11) v2(37.95,108.27) v2(38.06,95.36) v2(38.33,134.47) v2(40.52,46.36) v2(40.58,110.41) v2(41.76,134.47) v2(42.45,106.87) v2(44.99,94.44) v2(46.1,84.41) v2(46.09,83.54) v2(46.1,82.63) v2(46.43,94.41) v2(46.56,134.47) v2(47.02,124.34) v2(47.15,27.03) v2(47.22,106.35) v2(47.48,78.13) v2(47.63,110.54) v2(47.76,117.88) v2(47.96,94.41) v2(48.11,27.05) v2(48.69,78.44) v2(48.68,76.51) v2(48.85,111.08) v2(48.85,109.16) v2(49.71,123.04) v2(49.89,27.08) v2(50.7,118.39) v2(50.98,125.78) v2(50.96,110.97) v2(50.96,109.07) v2(51.39,27.05) v2(51.59,77.31) v2(51.59,75.4) v2(52.15,122.28) v2(52.53,35.41) v2(52.85,41.62) v2(53.01,97.36) v2(52.99,96.11) v2(53.27,110.19) v2(53.39,118.34) v2(54.56,111.28) v2(55.4,143.46) v2(55.38,140.9) v2(55.38,137.97) v2(55.38,136.32) v2(55.58,98.63) v2(55.55,96.72) v2(56.31,120.93) v2(56.54,123.83) v2(56.82,27.03) v2(57.15,131.19) v2(57.18,123.83) v2(57.97,143.49) v2(58.01,121.75) v2(58.14,99.92) v2(58.12,97.92) v2(58.17,98.6) v2(58.88,121.08) v2(59.44,133.09) v2(59.57,38.58) v2(59.59,36.93) v2(59.81,115.16) v2(60.56,118.67) v2(60.79,121.11) v2(61.88,27.12) v2(62.59,45.96) v2(62.67,93.09) v2(63.52,101.78) v2(63.48,100.48) v2(63.49,99.09) v2(63.5,97.83) v2(63.58,102.97) v2(63.73,91.15) v2(63.81,89.38) v2(63.94,93.04) v2(64.16,41.63) v2(64.63,87.65) v2(65.08,91.28) v2(65.24,133.65) v2(65.31,92.91) v2(65.33,85.78) v2(65.31,83.77) v2(65.28,46.23) v2(65.38,151.97) v2(65.4,89.18) v2(65.56,136.65) v2(65.56,136.02) v2(65.94,135.05) v2(65.94,134.39) v2(65.94,133.71) v2(65.86,94.23) v2(66.6,135.05) v2(66.6,134.39) v2(66.63,133.71) v2(66.83,84.63) v2(66.96,27.12) v2(67.34,135.05) v2(67.36,134.39) v2(67.39,133.71) v2(68,135.05) v2(68.05,134.39) v2(68.05,77.78) v2(68.08,133.71) v2(68.23,79.71) v2(68.51,94.24) v2(68.81,151.96) v2(69.24,94.38) v2(69.29,46.25) v2(69.65,78.13) v2(70.32,94.29) v2(70.28,79.19) v2(71.1,94.3) v2(71.22,80.62) v2(71.38,115.04) v2(71.54,45.57) v2(71.61,151.97) v2(71.62,87.88) v2(71.66,77.93) v2(71.66,76.02) v2(71.83,38.63) v2(72.04,115.04) v2(72.04,27.12) v2(73.18,137.42) v2(73.21,79.15) v2(73.15,46.08) v2(73.51,139.73) v2(73.64,153.44) v2(73.71,138.58) v2(73.82,93.55) v2(73.92,155.58) v2(74.55,93.57) v2(74.6,92.51) v2(74.55,91.54) v2(74.55,90.6) v2(74.84,48.36) v2(75.03,46.5) v2(75.52,155.98) v2(75.91,133.83) v2(76.18,136.63) v2(76.2,89.81) v2(76.2,89.17) v2(76.53,141.45) v2(76.71,135.15) v2(76.71,134.49) v2(76.71,133.81) v2(77.09,89.84) v2(77.12,27.12) v2(77.4,155.98) v2(77.37,135.15) v2(77.37,134.49) v2(77.4,133.81) v2(78.02,89.81) v2(78.11,135.15) v2(78.11,134.49) v2(78.11,133.81) v2(78.05,79.02) v2(78.05,77.09) v2(78.44,147.85) v2(78.46,150.09) v2(78.46,149.35) v2(78.46,148.57) v2(78.77,135.15) v2(78.77,134.49) v2(78.79,133.81) v2(79.35,150.12) v2(79.35,149.35) v2(79.35,148.57) v2(79.35,147.85) v2(79.68,132.84) v2(79.85,89.81) v2(79.96,155.98) v2(80.14,78.51) v2(80.14,76.58) v2(80.24,150.12) v2(80.24,149.35) v2(80.24,148.57) v2(80.24,147.85) v2(80.42,134.21) v2(80.42,133.58) v2(80.42,132.94) v2(81.67,89.81) v2(82.12,136.73) v2(82.2,27.12) v2(82.31,78.69) v2(82.45,133.78) v2(82.55,89.82) v2(82.98,134.49) v2(83.14,133.81) v2(83.34,135.18) v2(83.47,89.84) v2(83.46,80.29) v2(83.47,78.18) v2(83.77,134.49) v2(83.77,133.86) v2(83.86,155.96) v2(83.91,32.1) v2(83.98,135.18) v2(84.38,89.82) v2(84.51,153.6) v2(84.48,141.33) v2(84.47,140.68) v2(84.46,140.04) v2(84.48,134.47) v2(84.48,133.83) v2(84.61,135.18) v2(84.84,80.58) v2(84.83,79.31) v2(84.86,81.87) v2(85.14,134.49) v2(85.14,133.81) v2(85.25,135.18) v2(85.34,89.84) v2(86.31,80.47) v2(86.61,46.82) v2(87.28,27.12) v2(88.04,81.83) v2(88.12,77.98) v2(89.32,31.08) v2(89.77,31.55) v2(90.18,77.9) v2(90.17,75.78) v2(91.69,40.11) v2(92,149.18) v2(92,148.54) v2(92.01,147.91) v2(92.02,109.69) v2(92.08,152.71) v2(92.15,78.71) v2(92.31,107.85) v2(92.56,155.96) v2(92.56,154.43) v2(92.64,147.91) v2(93.3,147.91) v2(93.68,111.19) v2(93.69,109.29) v2(93.69,107.35) v2(94.14,149.58) v2(94.75,76.39) v2(94.72,75.12) v2(94.87,149.28) v2(95.74,155.98) v2(95.79,152.96) v2(95.79,152.33) v2(95.86,32.69) v2(96.07,111.25) v2(96.12,109.27) v2(96.52,78.64) v2(96.5,75.2) v2(97.24,102.72) v2(97.34,134.39) v2(98.02,155.98) v2(98.13,112.9) v2(98.15,109.02) v2(98.16,110.98) v2(98.5,119.21) v2(99.97,112.94) v2(100.07,78.69) v2(100.17,80.07) v2(100.28,155.98) v2(100.43,119.28) v2(100.64,74.48) v2(100.67,75.75) v2(100.99,109.87) v2(101.01,107.95) v2(101.08,111.86) v2(101.84,59.67) v2(102.47,155.98) v2(102.57,139.63) v2(104.98,155.98) v2(105.02,111.75) v2(105.54,100.88) v2(105.95,140.43) v2(106.18,114) v2(106.15,112.01) v2(106.16,109.93) v2(107.83,155.98) v2(107.88,114.38) v2(107.89,112.33) v2(107.91,110.26) v2(108.83,129.36) v2(109.01,41.33) v2(109.45,127.86) v2(109.5,121.08) v2(109.5,119.71) v2(109.52,112.21) v2(109.51,110.3) v2(110.83,128.17) v2(110.9,155.98) v2(111.1,104.09) v2(111.49,113.25) v2(111.63,126.73) v2(111.66,130.84) v2(111.7,109.35) v2(111.76,111.3) v2(112.27,119.36) v2(112.6,77.65) v2(113.03,155.98) v2(112.98,129.46) v2(113.72,106.78) v2(113.83,123.78) v2(113.83,122.71) v2(114.07,106.18) v2(114.32,82.54) v2(114.25,79.33) v2(114.35,106.78) v2(114.73,106.2) v2(115.21,78.18) v2(115.21,76.28) v2(115.27,80.9) v2(115.93,151.97) v2(116.11,107.9) v2(116.16,86.7) v2(116.92,89.02) v2(117.33,121.57) v2(117.3,119.48) v2(117.43,87.35) v2(117.88,126.44) v2(118.35,125.96) v2(118.72,120.27) v2(119.21,125.15) v2(119.28,119.58) v2(119.44,139.95) v2(120.22,124.23) v2(120.63,139.5) v2(120.67,123.76) v2(121.13,123.32) v2(121.57,122.86) v2(121.82,140.56) v2(122.15,113.82) v2(122.35,138.18) v2(122.53,27.02) v2(122.94,141.77) v2(123.42,139.19) v2(123.93,142.88) v2(124.31,140.06) v2(125.58,141.38) v2(126.19,118.11) v2(126.5,142.42) v2(127.49,130.66) v2(127.54,52.52) v2(128.48,110.62) v2(128.97,151.97) v2(130.31,151.97) v2(131.45,52.38) v2(131.37,40.71) v2(131.58,151.94) v2(132.01,40.72) v2(132.31,35.36) v2(132.51,41.35) v2(132.69,40.74) v2(132.97,52.62) v2(133.15,41.35) v2(133.35,40.71) v2(133.61,33.96) v2(133.73,52.62) v2(133.8,41.35) v2(133.83,30.84) v2(134.01,40.72) v2(134.43,41.34) v2(134.62,52.62) v2(134.64,40.71) v2(135.11,84.18) v2(135.11,83.54) v2(135.41,140.19) v2(135.36,139.02) v2(135.51,40.72) v2(136.35,147.63) v2(136.57,137.89) v2(137.13,137.28) v2(137.21,147.27) v2(137.49,148.64) v2(137.8,45.32) v2(137.95,146.08) v2(138.28,144.91) v2(138.29,138.42) v2(138.31,105.46) v2(138.99,52.76) v2(139.05,30.82) v2(139.21,151.94) v2(139.22,148.71) v2(139.42,138.46) v2(139.98,143.69) v2(140.34,142.55) v2(140.54,123.27) v2(141.29,46.66) v2(141.43,155.96) v2(141.43,154.08) v2(141.43,141.61) v2(141.61,124.39) v2(141.56,122.25) v2(142.34,141.12) v2(142.52,123.47) v2(143.08,124.59) v2(144.05,125.76) v2(144.09,30.82) v2(144.4,53.88) v2(144.55,155.96) v2(144.66,80.52) v2(144.66,79.38) v2(144.96,124.87) v2(145.22,79.95) v2(145.6,40.82) v2(145.8,80.52) v2(145.8,79.38) v2(146.43,128.39) v2(146.51,126.01) v2(146.56,49.03) v2(147.86,46.88) v2(148.31,129.53) v2(148.8,127.97) v2(149.19,30.82) v2(149.63,155.96) v2(151.26,121.85) v2(152.02,40.31) v2(153.29,153.72) v2(153.61,125.03) v2(153.6,120.23) v2(153.93,113.56) v2(154.15,30.84) v2(154.71,155.96) v2(154.82,113.55) v2(155.58,113.56) v2(156.47,113.55) v2(156.85,39.8) v2(157.22,47.65) v2(157.48,106.2) v2(157.48,104.6) v2(157.58,65.94) v2(157.65,39.8) v2(157.99,81.66) v2(159.15,39.8) v2(159.39,83.44) v2(159.37,30.82) v2(159.52,155.88) v2(159.87,100.38) v2(160.63,103.1) v2(160.81,140.93) v2(161.36,153.87) v2(162.03,104.52) v2(162.08,96.24) v2(162.28,33.84) v2(163.48,113.67) v2(163.49,82.04) v2(163.49,79.88) v2(163.6,105.26) v2(163.78,106.96) v2(164.17,113.67) v2(164.19,33.81) v2(164.42,106.96) v2(164.41,30.82) v2(164.9,110.14) v2(164.9,108.64) v2(165.05,106.96) v2(165.38,113.67) v2(165.97,105.44) v2(166.14,113.67) v2(166.53,112.24) v2(167.21,112.24) v2(167.74,95.36) v2(167.72,46.35) v2(168,151.77) v2(168.33,105.46) v2(168.38,134.46) v2(168.38,132.41) v2(168.38,122.23) v2(168.38,112.52) v2(168.38,107.39) v2(168.38,91.9) v2(168.38,84.46) v2(169.51,30.82) v2(171.15,80.37) v2(172.95,48.64) v2(174.54,30.82) v2(175.19,36.32) v2(175.82,36.32) v2(176.48,30.84) v2(177.46,30.82) v2(179.17,30.82) v2(180.9,30.82) v2(182.64,30.82) v2(184.04,70.11) v2(184.76,30.84) v2(185.63,33.45) v2(186.17,30.84) v2(188.42,54.89) v2(188.42,54.26) v2(190.33,41.12) v2(190.58,66.98) v2(190.99,40.46) v2(194.36,66.98) v2(194.82,33.96) v2(195.58,33.96) v2(198.55,66.98) v2(201.78,66.98) v2(202.35,49.93) v2(202.35,49.04) v2(202.35,48.15) v2(203.24,49.93) v2(203.24,49.04) v2(203.24,48.15) v2(203.56,56.74) v2(204.13,49.93) v2(204.13,49.04) v2(204.11,48.16) v2(204.95,30.92) v2(204.96,66.98) v2(204.99,57.84) v2(207.65,38.36) v2(208.23,67.29) v2(209.76,67.97) v2(210.19,47.32) v2(211.15,48.42) v2(212.02,62.87) v2(213.01,54.22) v2(213.29,51.98) v2(213.39,55.09) v2(213.97,62.85) v2(216.64,36.37) v2(217.96,34.04) v2(218.52,68.4) v2(219.87,69.17) v2(223.29,69.96) v2(224.84,35.23) v2(225.96,60.48) v2(225.96,55.47) v2(225.96,50.39) v2(225.96,48.08) v3(119.98,37.39) v3(120.58,37.95) v4(37.12,36.02) v4(37.15,36.88) v4(37.36,35.22) v4(37.51,37.66) v4(37.99,36.81) v4(37.98,35.97) v4(38.2,35.16) v4(38.35,37.64) v4(38.83,36.78) v4(38.82,35.94) v4(51.67,131.04) v4(52.33,131.7) v4(59.03,136.86) v4(59.08,136.02) v4(59.88,136.86) v4(59.92,136.02) v4(60.76,136.02) v4(60.96,119.64) v4(61.8,120.19) v4(61.78,119.32) v4(61.75,118.49) v4(62.69,127.51) v4(62.69,126.67) v4(62.69,125.83) v4(70.18,133.83) v4(70.18,133) v4(71.17,134.8) v4(71.78,131.65) v4(71.78,130.76) v4(71.78,129.74) v4(71.78,128.73) v4(71.78,127.84) v4(71.78,126.77) v4(71.78,125.88) v4(71.78,124.99) v4(71.78,124.11) v4(71.78,123.27) v4(72.04,134.82) v4(72.65,131.65) v4(72.65,130.76) v4(72.65,129.74) v4(72.65,128.73) v4(72.65,127.84) v4(72.67,126.77) v4(72.67,125.88) v4(72.67,124.99) v4(72.67,124.11) v4(72.67,123.27) v4(72.88,134.82) v4(76.09,97.57) v4(76.51,140.44) v4(76.63,139.37) v4(76.93,97.57) v4(77.77,97.57) v4(78.61,97.57) v4(79.44,97.57) v4(79.68,131.93) v4(79.68,131.04) v4(79.68,130.2) v4(79.68,129.36) v4(80.29,97.59) v4(80.55,131.93) v4(80.55,131.04) v4(80.55,130.2) v4(80.55,129.36) v4(81.13,97.59) v4(81.99,97.59) v4(82.82,95.86) v4(82.82,95.02) v4(82.82,94.18) v4(82.82,93.34) v4(88.14,128.22) v4(88.14,127.31) v4(88.14,126.47) v4(88.14,125.63) v4(88.17,132.79) v4(88.17,131.9) v4(88.17,130.89) v4(89.03,132.79) v4(89.03,131.9) v4(89.03,130.89) v4(89.02,128.2) v4(89.03,127.31) v4(88.98,126.47) v4(88.98,125.63) v4(89.18,138.25) v4(89.46,98.65) v4(89.46,97.64) v4(89.46,96.8) v4(89.46,95.86) v4(89.46,95.02) v4(89.46,94.06) v4(89.46,93.19) v4(89.78,138.85) v4(93.51,144.35) v4(95.61,98.65) v4(95.61,97.82) v4(95.61,96.75) v4(95.61,95.91) v4(95.61,94.92) v4(95.61,94.08) v4(95.61,93.24) v4(97.13,127.03) v4(97.13,126.09) v4(97.16,128.75) v4(97.16,127.86) v4(104.09,132.97) v4(104.09,132.13) v4(104.07,131.29) v4(104.36,133.77) v4(104.91,131.03) v4(105,131.97) v4(105.11,132.81) v4(105.31,150.06) v4(105.84,131.83) v4(105.82,130.99) v4(105.88,149.3) v4(105.94,132.68) v4(106.07,150.41) v4(106.7,149.43) v4(106.91,150.27) v4(107.54,149.43) v4(107.74,150.27) v4(110.39,144.15) v4(111.23,144.15) v4(111.98,31.4) v4(112.83,33.3) v4(112.83,32.46) v4(112.83,31.62) v4(112.83,30.79) v4(113.64,32.03) v4(138.2,81.26) v4(141.25,80.9) v4(141.58,102.64) v4(141.61,101.78) v4(141.65,100.89) v4(141.65,100) v4(141.65,99.11) v4(142.12,103.43) v4(142.5,101.78) v4(142.49,100.89) v4(142.49,100) v4(142.49,99.11) v4(143.33,99.11) v4(143.39,101.78) v4(143.38,100.89) v4(143.38,100) v4(146.29,88.32) v4(146.29,87.45) v4(146.29,86.62) v4(146.29,85.78) v4(146.29,84.94) v4(146.29,84.1) v4(146.31,83.26) v4(146.77,89.15) v4(147.2,88.32) v4(147.2,87.45) v4(147.2,86.62) v4(147.2,85.78) v4(147.2,84.94) v4(147.2,84.1) v4(147.23,83.26) v4(147.61,89.16) v4(148.06,88.32) v4(148.11,87.48) v4(148.11,86.64) v4(148.11,85.8) v4(148.11,84.96) v4(148.11,84.13) v4(148.11,83.29) v4(148.45,89.16) v4(149.08,87.48) v4(149.08,86.64) v4(149.08,85.8) v4(149.08,84.96) v4(149.1,84.13) v4(149.1,83.24) v4(150.93,83.01) v4(151.13,102.16) v4(151.13,101.27) v4(151.13,100.38) v4(151.13,99.49) v4(151.77,83.01) v4(152.02,102.16) v4(151.99,101.27) v4(151.99,100.38) v4(151.99,99.49) v4(151.99,98.6) v4(152.61,83.01) v4(152.83,101.27) v4(152.83,100.38) v4(152.83,99.49) v4(152.83,98.6) v4(152.91,102.16) v4(153.01,78.56) v4(178.72,45.75) v4(178.72,44.88) v4(179.61,45.75) v4(179.61,44.88) v4(180.47,45.75) v4(180.47,44.88) v4(191.7,47.14) v4(192.1,46.41) v4(192.54,47.14) v4(192.99,46.41) v4(193.4,47.14) v4(193.86,46.41) v4(194.26,47.14) v4(195.08,48.03)
