# Allegro board 17931-1.1228WZS1336.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SMBC_THERM_NV: length 21.2
  TOP w0.114: v2(137.08,123.19) v1(137.08,123.75)
  L3 w0.089: v2(137.08,123.19) 137.08,122.56 137.44,122.19 139.88,122.19 147.34,114.73 147.85,114.73 148.87,113.71 v2(148.87,112.84)
  BOTTOM w0.114: GPU1.D9 v2(137.08,123.19) ; Q7901.4 149.36,111.8 149.1,112.07 148.96,112.07 RN7901.2 v2(148.87,112.84)
SMBD_THERM_NV: length 25.9
  TOP w0.114: v2(148.22,112.84) 148.22,113.09 v1(148.68,113.55)
  L3 w0.089: v2(148.22,112.84) 148.22,112.97 148.47,113.21 148.47,113.38 148.51,113.43 148.51,113.78 148.47,113.83 148.47,113.84 147.77,114.54 147.26,114.54 139.8,122 137.37,122 136.15,123.21 v2(135.97,123.21)
  BOTTOM w0.114: v2(148.22,112.84) RN7901.1 147.92,112.15 145.94,110.18 145.94,109 146.22,108.72 Q7901.1 ; GPU1.D8 135.94,123.18 v2(135.97,123.21)
SML0_ALERT#: length 319.4
  TOP w0.114: R1806.1 38.51,94.82 37.62,94.82 35.63,96.81 32.27,96.81 31.27,95.81 31.27,94.3 29.15,92.18 v2(27.97,92.18) ; v2(28.17,23.16) 27.82,23.52 27.82,27.29 30.76,30.23 30.81,30.23 31.8,31.23 31.8,33.63 35.85,37.68 35.85,38.06 37,39.21 37,41.18 37.39,41.57 41.71,41.57 42.4,42.26 45.99,42.26 48.6,44.87 48.6,46.63 49.52,47.55 49.52,50.58 56,57.06 98.67,57.06 98.92,56.81 108.5,56.81 118.46,66.76 118.46,70.05 118.28,70.23 118.28,76.98 123.73,82.43 123.73,89.19 121.68,91.24 121.68,93.47 118.48,96.67 118.48,97.81 117.99,98.31 v2(117.83,98.31)
  L3 w0.089: v2(117.83,98.31) 114.29,98.31 113.31,97.33 109.75,97.33 v2(109.35,96.93) ; v2(28.17,23.16) 28.17,22.08 27.7,21.6 23.03,21.6 21.47,23.17 15.65,23.17 14.84,23.97 14.84,38.86 14.43,39.28 14.43,42.85 16.28,44.7 16.28,49.38 16.03,49.63 16.03,58.29 17.78,60.05 17.78,62.49 16.7,63.57 16.7,67.61 v2(16.75,67.67)
  BOTTOM w0.114: R1504.2 118.6,98.31 v2(117.83,98.31) ; v2(109.35,96.93) 109.01,97.27 CPU1.CG15 ; v2(16.75,67.67) 17.21,68.12 19.28,68.12 20.48,69.32 21.97,69.32 22.36,68.93 22.81,68.93 23.66,69.78 25.89,69.78 26.31,69.36 27.41,69.36 28.17,70.12 28.17,70.41 28.42,70.67 28.7,70.67 31.87,73.83 34.58,73.83 35.07,74.33 36.38,74.33 36.51,74.46 37.01,74.96 37.88,74.96 37.88,74.96 38.42,75.5 44.9,75.5 45.13,75.27 48.62,75.27 50.47,77.12 50.47,77.71 51.52,78.76 52.12,78.76 52.42,79.07 52.42,88.23 v1(52.61,88.42) 53.04,88.85 53.04,89.61 51.69,90.96 29.2,90.96 v2(27.97,92.18)
SML0_SMBCLK: length 15.8
  L6 w0.114: v2(116.08,96.93) 115.73,96.57 114.58,96.57 113.64,97.51 112.6,97.51 111.61,98.5 109.53,98.5 109.24,98.22 v2(109.24,97.97)
  BOTTOM w0.114: RN1807.6 121.35,96.05 v1(120.83,95.53) 120.53,95.24 117.46,95.24 116.08,96.61 v2(116.08,96.93) ; v2(109.24,97.97) 109.24,98.09 CPU1.CH14
SML0_SMBDATA: length 15.5
  L6 w0.114: v2(108.61,97.97) 109.21,97.37 111.6,97.37 111.94,97.03 113.8,97.03 114.56,96.27 116.44,96.27 v2(116.74,96.57)
  BOTTOM w0.114: v2(108.61,97.97) 108.36,97.71 CPU1.CF15 ; RN1807.7 121.28,96.55 120.33,95.6 119.76,95.6 119.76,95.59 119.46,95.59 119.45,95.6 v1(117.66,95.6) 117.62,95.6 116.74,96.48 v2(116.74,96.57)
SML1_SMBCLK: length 138.6
  TOP w0.114: R2459.1 197.87,64.77 v2(197.64,65)
  L5 w0.114: v2(132.51,93.79) 132.5,93.8 132.48,93.8 131.64,94.64 131.64,96.68 131.5,96.83 131.5,99.04 131.07,99.47 131.07,107.34 v2(131.98,108.25) 133.94,108.25 135,107.19 136.5,107.19 137.75,108.43 152.9,108.43 v2(153.01,108.54) 153.03,108.52 153.07,108.52 153.51,108.08 153.55,108.08 154.54,107.09 154.54,106.2 157.89,102.85 157.89,99.47 158.45,98.91 158.45,97.44 162.22,93.66 162.22,92.32 165.09,89.45 165.09,87.56 167.76,84.89 167.76,81.84 173.09,76.51 173.66,76.51 177.09,73.08 177.72,73.08 179.78,71.02 179.78,70.32 181.06,69.04 186.3,69.04 187.73,68.36 189.94,66.14 196.5,66.14 v2(197.64,65)
  BOTTOM w0.076: CPU1.CN15 112.58,97.68 112.62,97.62 113.11,97.44 113.35,97.44 113.41,97.46 113.95,97.46 114.28,97.13
  BOTTOM w0.114: v2(153.01,108.54) 152.78,108.77 151.9,108.77 151.53,109.14 RN1811.3 150.34,108.36 148.8,108.36 148.54,108.62 148.54,109.7 148.22,110.02 Q7901.3 ; Q2601.3 131.98,108.31 v2(131.98,108.25) ; 114.28,97.13 114.88,97.13 117.44,94.57 121.28,94.57 121.67,94.18 125.41,94.18 125.67,93.92 127.98,93.92 128.09,93.8 v1(128.93,93.8) 132.5,93.8 v2(132.51,93.79)
SML1_SMBDATA: length 144
  TOP w0.114: R2447.1 197.84,64.01 197.01,64.85 v2(197.01,65)
  L5 w0.114: v2(197.01,65) 196.17,65.84 189.91,65.84 187.59,68.16 186.24,68.8 181.16,68.8 181.16,68.8 180.96,68.8 179.54,70.22 179.54,70.92 177.62,72.84 176.99,72.84 173.56,76.27 172.99,76.27 167.52,81.74 167.52,84.79 164.85,87.45 164.85,89.35 161.98,92.22 161.98,93.56 158.21,97.34 158.21,98.81 157.65,99.37 157.65,102.75 154.28,106.11 154.28,106.86 153.23,107.91 v2(153.03,107.91) 152.8,108.14 137.86,108.14 136.66,106.94 134.9,106.94 134.06,107.78 v2(132.45,107.78) 131.32,106.66 131.32,99.57 131.78,99.11 131.78,96.89 131.89,96.78 131.89,94.76 132.41,94.24 132.71,94.24 132.72,94.24 132.74,94.24 133,93.98 133,93.65 132.97,93.62 132.97,93.62 132.71,93.37 132.71,93.37 132.54,93.19 v2(132.54,93.14)
  BOTTOM w0.076: 114.44,96.93 114.07,96.93 113.7,97.3 113.44,97.3 113.39,97.28 113.38,97.27 113.08,97.27 113.07,97.28 112.63,97.44 112.19,97.44 CPU1.CM15
  BOTTOM w0.114: v2(153.03,107.91) 153.04,107.92 153.04,107.93 153.45,108.34 153.45,109.52 153.45,109.52 153.45,109.88 152.91,110.43 151.78,110.43 151.37,110.02 RN1811.4 150.99,110.02 150.71,109.74 150.71,109.1 150.33,108.72 Q7901.6 ; 114.44,96.93 114.74,96.93 117.44,94.23 121.28,94.23 121.57,93.94 125.31,93.94 125.57,93.68 127.88,93.68 128.15,93.4 129.3,93.4 129.55,93.14 v1(130.38,93.14) v2(132.54,93.14) ; Q2601.6 131.55,110.57 131.55,110.39 130.61,109.45 130.61,108.85 131.68,107.78 v2(132.45,107.78)
SML1ALERT#: length 45
  TOP w0.114: R1837.2 137.89,69.22 137.53,68.86 v1(135.66,68.86) 135.57,68.96 v2(135.57,69.51)
  BOTTOM w0.076: 106.51,83.4 106.51,83.65 106.57,83.71 106.57,84 106.6,84.06 106.6,84.3 106.57,84.36 106.57,84.65 106.61,84.76 106.62,84.77 106.62,85.43 CPU1.CC34
  BOTTOM w0.114: 106.51,83.4 106.51,82.31 106.8,82.02 106.8,81.14 107.17,80.77 107.17,76.63 112.09,71.7 114.68,71.7 114.68,71.71 117.26,71.71 119.87,69.09 132.46,69.09 132.69,68.87 134.93,68.87 v2(135.57,69.51)
SPI_CLK_CPU: length 50.2
  TOP w0.114: v2(161.29,74.62) 161.29,75.59 R9138.1 ; v1(137.26,90.32) 137.07,90.32 v2(136.77,90.63) 136.63,90.49 R2513.2 136.11,91.2 R1842.1
  L5 w0.114: v2(134.51,77.08) 134.51,78.75 134.39,78.87 134.39,87.83 135.78,89.22 135.78,89.64 v2(136.77,90.63)
  L6 w0.114: v2(161.29,74.62) 160.57,75.34 135.3,75.34 134.51,76.14 v2(134.51,77.08)
  BOTTOM w0.114: R2508.2 131.14,78.31 132.04,77.41 133.13,77.41 133.47,77.08 v2(134.51,77.08)
SPI_CLK_CPU_R: length 54.8
  TOP w0.114: R1842.2 133.52,91.25 132.76,90.49 131.96,90.49 131.37,89.9 131.37,86.16 v1(131.17,85.95) 130.33,85.12 130.33,74.63 131.58,73.38 132.5,73.38 v2(132.54,73.34)
  BOTTOM w0.114: v2(132.54,73.34) 132.48,73.4 125.8,73.4 124.34,71.94 120.98,71.94 120.19,72.73 118.42,74.5 113.52,74.5 113.25,74.5 109.96,77.78 109.96,80.85 109.51,81.3 CPU1.CH37
SPI_CLK_ROM: length 3.5
  BOTTOM w0.114: BIOS1.6 131.48,81.02 132.11,80.39 v1(132.11,80.29) 132.11,79.53 131.93,79.35 EC2503.1 131.17,79.33 R2508.1
SPI_CLK_ROM2: length 3.3
  TOP w0.114: R2513.1 135.18,90.42 EC2504.1 135.18,89.35 v1(135.68,88.84) 136.29,88.24 BIOS2.6
SPI_CLK_ROM_TPM: length 2.6
  TOP w0.114: R9138.2 162.19,77.47 v1(162.26,77.47) 162.74,77.95 U9103.19
SPI_CS2#_IC: length 4.8
  TOP w0.114: 162.5,76.51 162.94,76.51 R9148.2 162.99,77.59 163.24,77.84 U9103.20 ; 162.5,76.51 R9130.2 ; 162.5,76.51 162.5,75.34 162.49,75.33 v1(162.49,74.65)
SPI_CS_CPU_N0: length 62
  TOP w0.114: v2(132.41,86.06) 132.33,86.06 131.22,84.95 v1(131.22,82.83) 131.22,75.72 132.59,74.35 132.67,74.35 133.6,73.41 133.6,73.02 133.86,72.77 134.86,72.77 135.11,73.02 135.11,73.05 135.26,73.2 v2(135.32,73.2)
  BOTTOM w0.114: BIOS1.1 128.94,87.07 128.62,86.74 127.61,86.74 R2519.2 128.34,85.81 132.16,85.81 v2(132.41,86.06) ; CPU1.CG36 108.73,84.05 108.73,80.66 108.93,80.46 108.93,77.36 112.82,73.47 113.95,73.47 117.99,73.47 119.16,72.3 120.55,70.91 124.77,70.91 126.06,72.2 134.32,72.2 v2(135.32,73.2)
SPI_CS_CPU_N1: length 47.7
  TOP w0.114: v2(134.67,73.2) 134.67,73.46 135.05,73.85 135.05,75.64 133.26,77.44 132.6,77.44 132.39,77.64 132.39,78.82 R2521.2 132.88,79.64 v1(133.58,80.34) 133.75,80.51 BIOS2.1
  BOTTOM w0.076: CPU1.CG35 109.07,84.41 109.08,84.39 109.11,84.3 109.11,84.06 109.09,84.01 108.99,83.69 108.97,83.66 108.97,83.61 108.96,83.59 108.96,82.94
  BOTTOM w0.114: 108.96,82.94 108.96,80.91 109.27,80.6 109.27,77.5 112.96,73.81 113.8,73.81 113.8,73.81 118.13,73.81 119.5,72.44 120.69,71.25 124.62,71.25 125.92,72.54 134.01,72.54 v2(134.67,73.2)
SPI_CS_CPU_N2: length 70
  TOP w0.114: R9130.1 161.93,75.51 v2(161.93,74.6) ; R9118.2 160.2,78.94 v2(160.15,78.89)
  L3 w0.089: v2(161.93,74.6) 161.93,75.82 161.65,76.1 161.65,77.93 160.68,78.89 v2(160.15,78.89)
  BOTTOM w0.076: 109.98,82.24 109.94,83.07 109.94,84 109.83,84.21 109.83,84.64 109.63,84.84 109.4,84.87 109.28,84.97 109.26,85.08 109.24,85.31 CPU1.CH34
  BOTTOM w0.114: 109.98,82.24 110.62,81.6 110.62,80.85 v1(110.57,80.8) 110.62,80.75 110.62,78.89 111.31,78.2 111.31,77.37 113.52,75.16 118.69,75.16 120.85,73 121.25,72.6 123.45,72.6 124.95,74.09 160.59,74.09 160.6,74.1 161.43,74.1 v2(161.93,74.6)
SPI_HOLD_CPU: length 19.1
  TOP w0.114: v2(133.78,89.05) 132.98,89.05 132.85,89.18 v1(132.85,89.51) 133.13,89.79 R1846.1 133.73,89.89 134.5,90.65 R2511.2
  BOTTOM w0.114: R2503.2 130.89,80.47 130.89,82.56 ; 130.89,82.56 132.68,84.35 132.68,84.65 133.7,85.66 133.7,88.96 v2(133.78,89.05) ; 130.89,82.56 130.34,83.11 128.96,83.11 127.92,82.07 126.83,82.07 126.65,82.25 R1510.2
SPI_HOLD_CPU_R: length 55.3
  TOP w0.114: R1846.2 133.45,90.65 132.95,90.15 132.1,90.15 131.8,89.84 131.8,89.81 131.78,89.79 v1(131.78,87.33) 131.78,86.03 130.67,84.93 130.67,75.78 132.45,74.01 132.52,74.01 133.16,73.37 v2(133.16,73.2)
  BOTTOM w0.076: 109.17,83.58 109.26,83.97 109.28,84.03 109.28,84.33 109.24,84.44 109.11,84.93 CPU1.CG34
  BOTTOM w0.114: 109.17,83.58 109.17,81.13 109.62,80.68 109.62,77.64 113.1,74.16 113.66,74.16 118.27,74.16 119.84,72.59 120.84,71.59 124.48,71.59 125.77,72.89 132.85,72.89 v2(133.16,73.2)
SPI_HOLD_ROM: length 2.6
  BOTTOM w0.114: BIOS1.7 130.21,80.69 130.39,80.51 130.39,80.12 R2503.1 130.25,79.98 v1(130.25,79.22)
SPI_HOLD_ROM2: length 2.4
  TOP w0.114: R2511.1 134.43,89.8 v1(134.43,88.95) 134.43,88.71 135.02,88.12 BIOS2.7
SPI_IRQ#_TPM2: length 5.7
  TOP w0.114: U9103.18 162.24,78.02 161.37,77.14 161.06,77.14 160.48,76.64 R9152.1 160.31,76.38 R9119.1 160.33,75.74 R9151.1 160.33,74.9 v1(159.52,74.08)
SPI_SI_CPU: length 55
  TOP w0.114: R1844.1 136.15,91.98 137.03,91.1 v2(137.21,91.1) 137.33,90.98 R2512.2 ; R9133.1 R1506.2 164.72,75.52 164.12,74.92 163.79,74.92 v1(163.73,74.86) 163.73,74.32 163.98,74.07 v2(163.98,73.85)
  L5 w0.114: v2(134.04,77.55) 134.01,77.57 134.01,87.94 135.44,89.36 135.44,89.97 136.57,91.1 v2(137.21,91.1)
  L6 w0.114: v2(163.98,73.85) 163.67,73.53 161.76,73.53 160.27,75.02 135.21,75.02 134.22,76.02 134.22,76.45 134.04,76.63 v2(134.04,77.55)
  BOTTOM w0.114: v2(134.04,77.55) 134.04,78 133.56,78.49 R2509.2
SPI_SI_CPU_R: length 72.4
  TOP w0.114: R1844.2 135.13,91.87 v1(133.66,91.87) 133.12,92.41 132.18,92.41 130.52,90.74 130.52,86.32 129.64,85.44 129.64,74.34 131.67,72.32 133.33,72.32 133.57,72.08 134.86,72.08 135.3,72.08 135.99,72.77 136.38,72.77 136.72,73.11 136.74,73.11 v2(136.83,73.2)
  BOTTOM w0.114: v2(136.83,73.2) 136.83,72.75 135.26,71.17 126.48,71.17 125.19,69.88 120.12,69.88 118.13,71.88 117.56,72.44 114.37,72.44 112.39,72.44 107.9,76.93 107.9,82.6 108.11,82.81 108.11,83.43 107.93,83.62 107.93,84.23 CPU1.CF36
SPI_SI_ROM: length 3.8
  BOTTOM w0.114: BIOS1.5 132.75,80.94 133.33,80.37 v1(133.33,80.21) 133.33,80.01 133.2,79.88 132.82,79.88 132.69,79.76 EC2501.1 132.72,79.35 R2509.1
SPI_SI_ROM2: length 3.7
  TOP w0.114: BIOS2.5 137.56,88.71 EC2505.1 138.15,89.43 R2512.1 138.48,90.45 v1(139.04,90.45)
SPI_SI_ROM_TPM: length 2.2
  TOP w0.114: R9133.2 163.86,76.86 163.48,77.24 v1(163.48,77.47) 163.74,77.73 U9103.21
SPI_SO_CPU: length 67
  TOP w0.114: v2(132.49,90.93) v1(131.85,90.93) 130.94,90.02 130.94,86.25 129.99,85.3 129.99,74.49 131.81,72.66 133.48,72.66 133.71,72.42 135.16,72.42 135.76,73.02 135.76,73.39 135.77,73.39 135.77,75.79 v2(135.11,76.46) 135.11,77.52 134.58,78.06 134.1,78.06 133.67,78.5 R1843.1 133.61,78.51 R2501.1 ; v2(164.19,74.48) 164.23,74.52 164.24,74.52 165.26,75.54 165.26,76.02 R9132.1
  L6 w0.114: v2(135.11,76.46) 135.92,75.64 161.51,75.64 162.67,74.48 v2(164.19,74.48)
  BOTTOM w0.114: v2(132.49,90.93) 131.34,90.93 131.09,90.68 R2502.1
SPI_SO_CPU_R: length 45.7
  TOP w0.114: R1843.2 135.09,78.5 135.73,77.86 135.73,77.62 135.84,77.52 v1(135.84,76.48) 136.58,75.74 136.58,73.77 136.22,73.41 136.22,73.23 v2(136.2,73.2)
  BOTTOM w0.114: CPU1.CF37 108.32,83.74 108.32,81.54 108.25,81.46 108.25,77.07 112.53,72.78 114.23,72.78 117.71,72.78 118.47,72.02 120.27,70.22 125.05,70.22 126.34,71.51 134.75,71.51 136.2,72.96 v2(136.2,73.2)
SPI_SO_ROM: length 3.3
  BOTTOM w0.114: v1(131.42,90.15) 131.35,90.07 131.35,90.07 131.09,89.82 R2502.2 130.51,89.84 EC2502.1 129.77,89.61 130.21,89.17 BIOS1.2
SPI_SO_ROM2: length 3.3
  TOP w0.114: BIOS2.2 v1(135.02,81.08) 135.02,80.88 EC2506.1 134.39,79.37 R2501.2
SPI_SO_ROM_TPM: length 2.3
  TOP w0.114: U9103.24 165.24,78.3 165.87,77.67 R9132.2 166.35,77.01 v1(166.75,77.01)
SPI_WP_CPU: length 18
  TOP w0.114: v2(132.49,83.24) 132.65,83.08 135.4,83.08 135.77,82.71 135.77,81.41 136.27,80.9 v1(136.27,80.15) 136.03,79.91 R2510.1 135.99,79.22 R1845.1
  BOTTOM w0.114: R2507.1 134.85,90.73 R1508.2 135.26,90.22 135.26,89.55 135.11,89.4 134.79,89.4 134.04,88.65 134.04,85.52 133.02,84.5 133.02,83.77 v2(132.49,83.24)
SPI_WP_CPU_R: length 47.6
  TOP w0.114: v2(137.47,73.2) 137.47,73.36 137.32,73.51 v1(137.32,75.39) 137.32,77.75 136.86,78.21 R1845.2
  BOTTOM w0.114: CPU1.CF34 108.52,85.49 108.52,80.01 108.59,79.95 108.59,77.22 112.68,73.13 114.09,73.13 117.85,73.13 118.81,72.16 120.41,70.57 124.91,70.57 126.2,71.86 134.61,71.86 135.76,73.01 135.76,73.39 136.02,73.64 137.04,73.64 v2(137.47,73.2)
SPI_WP_ROM: length 4.4
  BOTTOM w0.114: BIOS1.3 131.48,89.64 132.24,90.4 132.71,90.4 132.72,90.41 v1(132.76,90.41) 132.8,90.45 132.9,90.45 133.99,91.54 R2507.2
SPI_WP_ROM2: length 3.3
  TOP w0.114: R2510.2 136.9,81.19 v1(136.91,81.2) 136.29,81.82 BIOS2.3
SPKR: length 273.7
  TOP w0.127: v2(24.16,22.02) 24.45,22.32 24.45,23.66 24.47,23.68 24.47,23.69 24.9,24.12 24.9,25.22 R2740.1 ; v2(103.2,30.23) v1(103.38,29.62)
  L5 w0.127: v2(103.2,30.23) 102.73,29.76 95.2,29.76 94.54,30.42 91.05,30.42 89.7,29.07 40.88,29.07 34.25,22.45 34.25,22.07 33.28,21.09 32.78,21.09 31.57,19.88 29.78,19.88 29.48,19.58 25.69,19.58 24.16,21.12 v2(24.16,22.02) ; v2(107.6,85.48) 109.05,84.04 109.05,77.53 120.51,66.06 120.51,65.29 128.49,57.32 162.63,57.32 164.63,59.32 164.66,59.32 164.8,59.46 166.3,59.46 166.32,59.48 166.68,59.48 168.19,57.97 168.19,53.6 170.17,51.61 170.17,44.41 170.17,44.41 170.17,44.12 169.6,43.55 168.95,43.55 168.95,43.55 168.56,43.55 168.56,43.55 168.27,43.55 168.12,43.55 133.72,43.55 131.8,45.47 131.65,45.47 131.08,46.04 110.58,46.04 109.67,45.12 104.37,45.12 103.26,46.23 v2(99.93,46.23)
  BOTTOM w0.127: v2(99.93,46.23) 100.45,45.71 100.45,42.67 100.1,42.33 100.1,39.83 101.98,37.95 101.98,35.96 101.69,35.67 101.69,35.3 101.9,35.09 101.9,33.78 103.2,32.49 v2(103.2,30.23) ; CPU1.CF35 107.93,85.16 v2(107.6,85.48)
SRTC_RST#: length 89.3
  TOP w0.127: v2(166.93,58.17) 166.93,58.83 166.94,58.85 166.94,59.83 v1(166.85,59.92) 166.08,60.69 166.08,64.07 167.19,65.18 ED1801.2 167.66,65.87 C1805.1 167.88,67.02 RN1801.3
  L6 w0.127: v2(166.93,58.17) 165.6,58.17 165.58,58.14 163.86,58.14 161.97,56.26 129,56.26 115.5,69.76 115.5,70.1 v2(103.15,82.45)
  BOTTOM w0.127: CPU1.BR37 102.24,83.58 102.24,82.75 102.54,82.45 v2(103.15,82.45)
SSD2_DEVSLP: length 5.8
  BOTTOM w0.089: CPU1.CR8 118.09,102.08 v1(118.29,101.88) 118.48,101.69 R1619.1
SSD_CLK_CPU_N_4: length 147.3
  L5 w0.102: v2(92.01,109.05) 91.79,108.83 91.38,108.83 91.18,109.03 91.18,111.04 87.03,115.19 73.04,115.19 72.34,114.49 66.89,114.49 64.82,112.42 64.7,112.42 64.5,112.42 62.02,109.94 62.02,106.59 59.44,104.01 59.44,99.35 58.88,98.79 58.88,98.05 57.13,96.29 55.3,96.29 53.29,94.29 53.29,93.35 50.3,90.35 50.3,88.97 51.03,88.24 51.03,81.63 50.35,80.95 50.35,79.12 49.84,78.61 49.84,76.53 48.14,74.83 48.14,72.14 46,70 46,68.68 42.59,65.28 41.15,65.28 38.71,62.84 38.71,61.9 33.91,57.1 33.91,56.06 32.67,54.81 32.5,54.81 29.49,51.81 29.49,50.12 27.77,48.39 27.77,46.11 34.15,39.73 34.15,37.52 33.75,37.12 32.2,37.12 32.2,37.12 31.55,37.12 30.68,36.26 25.71,36.26 23.95,34.49 23.4,34.49 23.22,34.67 22.69,34.67 v2(22.48,34.88)
  BOTTOM w0.114: CPU1.BA1 92.97,106.54 92.97,108.59 92.6,108.96 92.1,108.96 v2(92.01,109.05) ; SSD1.53 23.45,33.05 23.32,33.18 23.32,34.34 22.97,34.69 22.67,34.69 v2(22.48,34.88)
SSD_CLK_CPU_P_4: length 147.4
  L5 w0.102: v2(92.01,108.41) 91.79,108.63 91.3,108.63 90.98,108.94 90.98,110.95 86.95,114.99 73.13,114.99 72.43,114.29 66.98,114.29 64.91,112.22 64.78,112.22 64.58,112.22 62.22,109.85 62.22,106.51 59.64,103.93 59.64,99.26 59.08,98.71 59.08,97.96 57.21,96.09 55.38,96.09 53.5,94.2 53.5,93.26 50.5,90.27 50.5,89.05 51.23,88.32 51.23,81.55 50.55,80.87 50.55,79.04 50.04,78.53 50.04,76.45 48.34,74.75 48.34,72.05 46.2,69.91 46.2,68.6 42.68,65.08 41.24,65.08 38.92,62.76 38.92,61.82 34.12,57.02 34.12,55.97 32.75,54.61 32.58,54.61 29.7,51.73 29.7,50.03 27.97,48.3 27.97,46.2 34.35,39.82 34.35,37.43 33.84,36.92 32.11,36.92 31.63,36.92 30.77,36.06 25.8,36.06 24.03,34.29 23.31,34.29 23.13,34.47 22.71,34.47 v2(22.48,34.24)
  BOTTOM w0.114: v2(22.48,34.24) 22.7,34.46 22.88,34.46 23.09,34.24 23.09,33.19 22.95,33.05 SSD1.55 ; v2(92.01,108.41) 92.33,108.73 92.51,108.73 92.74,108.49 92.74,106.44 92.74,106.44 92.74,106.12 CPU1.BA2
SSD_DEVSLP: length 8.6
  BOTTOM w0.076: CPU1.CM8 111.95,101.83 112.93,101.83 113.03,101.73 113.27,101.73 113.31,101.71 113.37,101.64 114.9,101.64 114.94,101.6
  BOTTOM w0.089: 114.94,101.6 115.63,100.91 116.15,100.91 116.69,101.45 v1(117,101.45) 118.68,101.45 R1618.1
SSD_DEVSLP_R: length 143.8
  TOP w0.089: v2(120.78,101.47) 119.99,100.69 119.99,96.92 123.09,93.82 123.09,91.67 125,89.76 125,70.25 110.1,55.35 98.28,55.35 98.03,55.6 56.69,55.6 51.91,50.82 51.91,34 50.85,32.95 v1(44.99,32.95) R6301.1
  BOTTOM w0.089: v2(120.78,101.47) 120.48,101.78 120.18,101.78 R1619.2 R1618.2
SSD_PCIE_RX_N13: length 174.2
  L5 w0.102: v2(32.54,39.45) 32.34,39.24 31.78,39.24 31.46,38.93 31.46,38.01 30.32,36.87 24.79,36.87 24.29,37.37 24.29,41.7 25.25,42.67 25.25,49.3 27.18,51.23 27.18,52.75 29.39,54.96 29.39,55.88 33.15,59.64 33.15,64.33 35.39,66.57 37.81,66.57 39.93,68.7 39.93,70.4 42.98,73.45 42.98,80.45 42.32,81.11 42.32,91.23 43.04,91.95 47.27,91.95 49.57,94.24 49.57,99.94 51.79,102.17 51.79,104.36 52.84,105.4 52.84,111.2 53.42,111.79 54.94,111.79 57.2,114.05 57.2,115.11 57.84,115.75 61.78,115.75 66.28,120.24 92.88,120.24 99.29,113.83 99.29,108.08 99.64,107.73 99.64,106.34 98.65,105.36 98.65,103.81 v2(99.09,103.37)
  BOTTOM w0.114: v2(32.54,39.45) 32.77,39.22 33.92,39.22 35.07,38.06 35.07,33.89 35.31,33.65 35.31,33.2 35.45,33.06 SSD1.5 ; v2(99.09,103.37) 98.64,103.15 CPU1.BK6
SSD_PCIE_RX_N14: length 160.5
  L5 w0.102: v2(30.74,39.47) 30.53,39.26 29.8,39.26 25.99,43.08 25.99,49.12 27.79,50.92 27.79,52.45 30.05,54.71 30.05,55.6 33.81,59.36 33.81,64.05 35.16,65.41 38.52,65.41 41.53,68.42 41.53,70.94 43.59,72.99 43.59,81.68 44.1,82.19 44.1,84.85 42.95,85.99 42.95,90.86 43.44,91.34 47.52,91.34 50.18,94 50.18,99.57 52.56,101.94 52.56,103.88 54.05,105.38 54.05,109.86 57.86,113.67 60.56,113.67 66.38,119.48 92.52,119.48 98.61,113.39 98.61,107.9 98.96,107.55 98.96,106.74 97.72,105.5 97.72,103.81 v2(98.17,103.36)
  BOTTOM w0.114: v2(30.74,39.47) 30.94,39.27 31.35,39.27 31.74,38.88 31.74,34.81 32.28,34.27 32.28,33.47 32.45,33.3 SSD1.17 ; v2(98.17,103.36) CPU1.BJ6
SSD_PCIE_RX_N15: length 153.9
  L5 w0.102: v2(97.24,104) 97.01,104.24 97.01,105.48 97.7,106.17 97.7,113.47 92.55,118.62 88.72,118.62 88.44,118.9 66.37,118.9 60.35,112.88 57.64,112.88 54.51,109.75 54.51,103.21 50.65,99.35 50.65,93.86 48.01,91.22 48.01,86.24 46.94,85.17 46.94,78.96 46.61,78.63 46.61,72.42 44.68,70.49 44.68,69.2 42.74,67.26 41.3,67.26 38.13,64.09 35.49,64.09 34.27,62.87 34.27,59.22 30.48,55.43 30.48,54.54 28.2,52.25 28.2,50.67 26.44,48.92 26.44,43.27 28.28,41.44 28.72,41.44 29.04,41.76 v2(29.37,41.76)
  BOTTOM w0.114: v2(29.37,41.76) 29.03,41.76 28.78,41.51 28.78,36.42 29.31,35.89 29.31,33.43 29.45,33.3 SSD1.29 ; CPU1.BG5 97.23,103.99 97.23,103.99 97.24,104 v2(97.24,104)
SSD_PCIE_RX_N16: length 150.8
  L5 w0.102: v2(96.33,104.03) 95.99,104.03 95.76,104.26 95.76,105.28 96.9,106.42 96.9,112.9 91.9,117.91 88.33,117.91 88.13,118.11 66.7,118.11 60.83,112.24 57.87,112.24 55.17,109.54 55.17,102.49 51.62,98.93 51.62,93.95 48.67,91.01 48.67,86.04 47.93,85.3 47.93,75.87 47.25,75.19 47.25,72.16 45.34,70.26 45.34,68.92 43.05,66.63 41.58,66.63 37.62,62.66 35.78,62.66 34.93,61.81 34.93,58.98 33.3,57.35 33.3,56.51 32.27,55.48 32.27,55.45 28.83,52.01 28.83,50.39 27.1,48.67 27.1,45.89 28.6,44.39 28.6,43.61 28.48,43.49 28.25,43.49 v2(28.07,43.66)
  BOTTOM w0.114: v2(28.07,43.66) 27.86,43.45 27.58,43.45 26.09,41.96 26.09,33.43 25.95,33.3 SSD1.43 ; v2(96.33,104.03) 96.33,104.03 CPU1.BE5
SSD_PCIE_RX_P13: length 174.1
  L5 w0.102: v2(99.08,104.04) 98.99,104.04 98.86,104.18 98.86,105.27 99.84,106.26 99.84,107.82 99.49,108.16 99.49,113.91 92.96,120.45 66.19,120.45 61.7,115.95 57.75,115.95 57,115.2 57,114.13 54.86,111.99 53.33,111.99 52.63,111.29 52.63,105.49 51.59,104.45 51.59,102.25 49.36,100.03 49.36,94.33 47.19,92.15 43.12,92.15 43.12,92.15 42.95,92.15 42.12,91.32 42.12,81.03 42.78,80.37 42.78,73.53 39.73,70.49 39.73,68.78 37.72,66.78 35.31,66.78 32.95,64.42 32.95,59.72 29.19,55.97 29.19,55.04 26.98,52.83 26.98,51.32 25.05,49.39 25.05,42.75 24.08,41.78 24.08,37.29 24.7,36.67 30.4,36.67 31.66,37.93 31.66,38.84 31.86,39.04 32.31,39.04 v2(32.54,38.81)
  BOTTOM w0.114: SSD1.7 34.95,33.02 35.08,33.16 35.08,33.56 34.85,33.79 34.85,37.97 33.82,38.99 32.72,38.99 v2(32.54,38.81) ; CPU1.BK5 99,103.96 v2(99.08,104.04)
SSD_PCIE_RX_P14: length 160.6
  L5 w0.102: v2(30.76,38.84) 30.56,39.04 30.56,39.04 30.54,39.06 29.72,39.06 25.78,43 25.78,49.2 27.59,51 27.59,52.54 29.85,54.8 29.85,55.69 33.61,59.45 33.61,64.14 35.08,65.61 38.43,65.61 41.33,68.5 41.33,71.02 43.39,73.08 43.39,81.76 43.89,82.27 43.89,84.76 42.75,85.9 42.75,90.94 43.35,91.54 47.44,91.54 49.98,94.08 49.98,99.65 52.35,102.02 52.35,103.96 53.85,105.46 53.85,109.95 57.77,113.87 60.48,113.87 66.29,119.69 92.6,119.69 98.81,113.48 98.81,107.99 99.16,107.63 99.16,106.66 97.92,105.41 97.92,104.14 98.05,104.02 v2(98.17,104.02)
  BOTTOM w0.114: CPU1.BJ5 97.94,103.72 98.1,103.8 v2(98.17,104.02) ; v2(30.76,38.84) 30.97,39.04 31.25,39.04 31.51,38.78 31.51,34.72 32.05,34.18 32.05,33.4 31.95,33.3 SSD1.19
SSD_PCIE_RX_P15: length 153.9
  L5 w0.102: v2(28.91,42.22) 28.91,41.91 28.64,41.64 28.37,41.64 26.65,43.36 26.65,48.84 28.4,50.59 28.4,52.16 30.69,54.45 30.69,55.35 34.47,59.13 34.47,62.78 35.57,63.88 38.21,63.88 41.39,67.06 42.83,67.06 44.88,69.11 44.88,70.41 46.82,72.34 46.82,78.54 47.15,78.87 47.15,85.09 48.21,86.16 48.21,91.14 50.85,93.78 50.85,99.26 54.71,103.12 54.71,109.66 57.73,112.68 60.43,112.68 66.45,118.7 88.36,118.7 88.64,118.42 92.47,118.42 97.5,113.39 97.5,106.26 96.8,105.56 96.8,103.48 96.93,103.36 v2(97.24,103.36)
  BOTTOM w0.114: v2(97.24,103.36) 97.02,103.43 96.86,103.36 CPU1.BG6 ; v2(28.91,42.22) 28.91,41.96 28.55,41.61 28.55,36.33 29.09,35.8 29.09,33.43 28.95,33.3 SSD1.31
SSD_PCIE_RX_P16: length 150.8
  L5 w0.102: v2(96.34,103.39) 95.56,104.18 95.56,105.36 96.7,106.5 96.7,112.82 91.81,117.71 88.24,117.71 88.04,117.91 66.78,117.91 60.92,112.04 57.96,112.04 55.38,109.46 55.38,102.41 51.82,98.85 51.82,93.87 48.87,90.92 48.87,85.95 48.14,85.22 48.14,75.79 47.45,75.1 47.45,72.08 45.55,70.17 45.55,68.84 43.13,66.42 41.67,66.42 37.7,62.46 35.87,62.46 35.13,61.72 35.13,58.9 33.51,57.27 33.51,56.42 32.48,55.39 32.48,55.37 29.04,51.93 29.04,50.31 27.31,48.58 27.31,45.98 28.81,44.48 28.81,43.53 28.56,43.28 28.32,43.28 v2(28.07,43.03)
  BOTTOM w0.114: SSD1.41 26.45,33.3 26.31,33.43 26.31,41.86 27.67,43.22 27.88,43.22 v2(28.07,43.03) ; CPU1.BE6 95.93,103.39 96.09,103.47 v2(96.34,103.39)
SSD_PCIE_TX_CON_N13: length 2.3
  BOTTOM w0.114: C6316.1 33.81,34.35 33.81,33.43 33.95,33.3 SSD1.11
SSD_PCIE_TX_CON_N14: length 2.8
  BOTTOM w0.114: C6314.1 30.81,34.89 30.81,33.43 30.95,33.3 SSD1.23
SSD_PCIE_TX_CON_N15: length 2.6
  BOTTOM w0.114: SSD1.35 27.95,33.3 27.81,33.43 27.81,34.7 C6312.1
SSD_PCIE_TX_CON_P13: length 2.3
  BOTTOM w0.114: SSD1.13 33.45,33.3 33.59,33.43 33.59,34.37 C6315.1
SSD_PCIE_TX_CON_P14: length 2.8
  BOTTOM w0.114: C6313.1 30.59,34.86 30.59,33.43 30.45,33.3 SSD1.25
SSD_PCIE_TX_CON_P15: length 2.6
  BOTTOM w0.114: C6311.1 27.59,34.67 27.59,33.43 27.45,33.3 SSD1.37
SSD_PCIE_TX_N13: length 153
  L6 w0.102: v2(98.15,112.26) 98.42,112.26 98.58,112.26 98.94,112.26 99.38,111.83 99.38,111.26 99.85,110.79 99.85,107.97 99.51,107.63 99.51,106.46 98.47,105.42 95.47,105.42 94.43,104.39 93.62,104.39 92.14,105.87 90.95,105.87 89.91,106.91 89.91,108.68 89.63,108.97 73.46,108.97 72.44,107.95 72.44,105.77 70.84,104.17 70.84,103.56 69.95,102.67 67.52,102.67 66.36,101.51 66.36,96.96 64.05,94.65 62,94.65 61.51,94.16 60.73,94.16 60.47,93.9 60.47,89.74 63.93,86.28 63.93,82.82 60.53,79.43 59.55,79.43 55.94,75.82 55.94,69.82 36.89,50.78 32.52,50.78 31.23,49.48 28.66,49.48 27.64,48.46 27.64,42.83 29.39,41.07 32.39,41.07 33.26,40.2 33.26,37.96 v2(33.48,37.75)
  BOTTOM w0.076: CPU1.BM4 100.01,105.31 100.04,105.41 100.04,105.66 99.9,105.94 99.89,105.94 99.89,107.93 99.39,108.43 99.39,108.76 99.42,108.79 99.42,108.81
  BOTTOM w0.114: v2(33.48,37.75) 33.48,37.32 34.09,36.71 C6316.2 ; v2(98.15,112.26) 98.77,112.26 99.06,111.97 99.06,110.79 99.42,110.43 99.42,108.81
SSD_PCIE_TX_N14: length 141.6
  L6 w0.102: v2(29.98,37.95) 29.34,37.95 28.53,38.76 28.53,41.02 26.98,42.57 26.98,48.71 28.51,50.24 31.13,50.24 32.24,51.36 34.24,51.36 55.32,72.44 55.32,77 58.58,80.27 60.39,80.27 63.24,83.12 63.24,86.13 59.88,89.49 59.88,94.28 60.59,94.99 61.36,94.99 61.71,95.35 63.84,95.35 65.74,97.25 65.74,101.95 67.63,103.84 68.73,103.84 71.16,106.27 71.16,107.72 72.99,109.55 90.26,109.55 90.67,109.14 90.67,108.35 93.39,105.63 94.71,105.63 95.28,106.21 95.28,107.31 95.87,107.9 98.35,107.9 99.17,108.72 99.17,110.04 98.9,110.31 v2(98.15,110.31)
  BOTTOM w0.076: CPU1.BL2 99.54,106.4 99.54,107.67 98.9,108.3 98.9,108.34
  BOTTOM w0.114: C6314.2 31.07,37.19 30.51,37.75 30.18,37.75 v2(29.98,37.95) ; 98.9,108.34 98.83,108.4 98.83,109.88 98.57,110.14 98.32,110.14 v2(98.15,110.31)
SSD_PCIE_TX_N15: length 143
  L6 w0.102: v2(26.93,38.66) 26.67,38.41 26.44,38.41 26.32,38.53 26.32,48.99 28.17,50.84 30.88,50.84 31.98,51.94 33.86,51.94 53.25,71.34 53.25,75.77 58.33,80.85 59.49,80.85 62.55,83.91 62.55,84.87 55.05,92.37 55.05,94.41 56.39,95.75 61.19,95.75 61.8,96.37 63.95,96.37 65.08,97.49 65.08,102.12 67.38,104.42 68.32,104.42 70.03,106.13 70.03,107.42 72.91,110.3 92.17,110.3 93.56,111.69 95.02,111.69 95.51,112.17 95.83,112.17 v2(96.07,111.96)
  BOTTOM w0.076: CPU1.BL4 99.22,104.78 98.97,105.04 98.97,105.04 98.94,105.06 98.94,105.34 98.8,105.66 98.8,105.66 98.79,105.67 98.79,105.97 98.82,106.05 98.82,106.27 98.8,106.32 98.79,106.35 98.79,106.74 98.98,106.93 98.98,107.31 98.5,107.79 98.47,107.79
  BOTTOM w0.114: v2(26.93,38.66) 27.13,38.46 27.51,38.46 27.8,38.16 27.8,36.13 C6312.2 ; v2(96.07,111.96) 96.28,112.17 96.59,112.17 96.7,112.05 96.7,110.9 97.39,110.21 97.39,108.87 98.47,107.79
SSD_PCIE_TX_N16: length 143.6
  L6 w0.102: v2(24.9,38.03) 25.09,38.22 25.41,38.22 25.66,38.46 25.66,49.25 27.89,51.49 30.66,51.49 31.7,52.53 33.58,52.53 38.81,57.76 38.81,59.43 40.06,60.67 40.06,62.54 41.61,64.09 43.52,64.09 49.72,70.28 51.32,70.28 52.57,71.54 52.57,75.93 57.15,80.51 57.15,82.32 56.46,83.01 56.46,89.5 54.43,91.53 54.43,94.65 56.73,96.95 63.68,96.95 64.29,97.56 64.29,102.58 72.59,110.88 91.93,110.88 94.32,113.28 96.72,113.28 97.06,112.93 97.06,111.14 96.38,110.46 96.2,110.46 v2(96.07,110.59)
  BOTTOM w0.076: CPU1.BJ4 98.07,104.86 98.19,105.13 98.22,105.43 98.34,105.69 98.34,105.97 98.31,106.05 98.31,106.27 98.33,106.32 98.34,106.35 98.34,106.74 97.95,107.13 97.95,107.63 97.65,107.93 97.65,107.97 97.64,107.97
  BOTTOM w0.114: C6303.2 24.81,35.8 24.81,36.39 24.26,36.93 24.26,38.13 24.39,38.25 24.67,38.25 v2(24.9,38.03) ; v2(96.07,110.59) 96.3,110.36 96.58,110.36 96.85,110.09 96.85,108.76 97.64,107.97
SSD_PCIE_TX_P13: length 152.9
  L6 w0.102: v2(32.85,37.75) 33.06,37.96 33.06,40.11 32.31,40.87 29.31,40.87 27.44,42.74 27.44,48.54 28.58,49.68 31.14,49.68 32.44,50.98 36.81,50.98 55.74,69.91 55.74,75.9 59.46,79.63 60.45,79.63 63.72,82.91 63.72,86.2 60.26,89.66 60.26,93.98 60.65,94.36 61.42,94.36 61.91,94.85 63.97,94.85 66.16,97.05 66.16,101.6 67.43,102.87 69.87,102.87 70.64,103.64 70.64,104.25 72.24,105.85 72.24,108.04 73.38,109.17 89.71,109.17 90.11,108.77 90.11,106.99 91.04,106.07 92.23,106.07 93.71,104.59 94.35,104.59 95.38,105.63 98.39,105.63 99.31,106.55 99.31,107.72 99.65,108.05 99.65,110.7 99.17,111.18 99.17,111.75 98.86,112.06 98.69,112.06 98.55,111.93 98.55,111.73 98.45,111.63 v2(98.15,111.63)
  BOTTOM w0.076: 99.19,108.81 99.19,108.79 99.22,108.76 99.22,108.36 99.71,107.86 99.71,106 99.54,105.83 99.54,105.64 99.66,105.51 CPU1.BM3
  BOTTOM w0.114: v2(98.15,111.63) 98.36,111.84 98.36,111.84 98.52,112.01 98.7,112.01 98.83,111.88 98.83,110.69 99.19,110.34 99.19,108.81 ; C6315.2 33.33,35.78 33.47,35.92 33.73,35.92 33.86,36.05 33.86,36.62 33.25,37.22 32.97,37.22 32.85,37.35 v2(32.85,37.75)
SSD_PCIE_TX_P14: length 141.5
  L6 w0.102: v2(98.13,109.67) 98.4,109.67 98.53,109.8 98.53,109.98 98.65,110.11 98.81,110.11 98.96,109.96 98.96,108.8 98.27,108.1 95.79,108.1 95.08,107.4 95.08,106.3 94.62,105.84 93.48,105.84 90.88,108.44 90.88,109.22 90.34,109.75 72.91,109.75 70.96,107.81 70.96,106.36 68.64,104.04 67.54,104.04 65.54,102.03 65.54,97.33 63.75,95.55 61.63,95.55 61.27,95.19 60.51,95.19 59.68,94.37 59.68,89.4 63.03,86.05 63.03,83.2 60.3,80.47 58.5,80.47 55.12,77.09 55.12,72.52 34.16,51.56 32.16,51.56 31.04,50.45 28.43,50.45 26.77,48.79 26.77,42.49 28.32,40.94 28.32,38.68 29.26,37.75 29.54,37.75 v2(29.98,37.31)
  BOTTOM w0.076: 98.74,108.18 98.77,108.18 99.36,107.59 99.36,106.62 CPU1.BL1
  BOTTOM w0.114: v2(98.13,109.67) 98.13,109.77 98.28,109.91 98.48,109.91 98.61,109.78 98.61,108.31 98.74,108.18 ; v2(29.98,37.31) 30.18,37.52 30.41,37.52 30.84,37.09 30.84,36.76 30.71,36.63 30.21,36.63 30.08,36.5 30.08,36.28 C6313.2
SSD_PCIE_TX_P15: length 142.9
  L6 w0.102: v2(26.93,38.03) 26.75,38.2 26.36,38.2 26.11,38.45 26.11,49.07 28.09,51.05 30.8,51.05 31.9,52.15 33.78,52.15 53.05,71.42 53.05,75.86 58.25,81.05 59.41,81.05 62.35,84 62.35,84.78 54.84,92.29 54.84,94.5 56.3,95.95 61.1,95.95 61.72,96.57 63.87,96.57 64.87,97.58 64.87,102.2 67.29,104.62 68.24,104.62 69.83,106.21 69.83,107.5 72.83,110.5 92.08,110.5 93.48,111.89 94.94,111.89 95.42,112.38 95.79,112.38 v2(96.04,112.62)
  BOTTOM w0.076: 98.63,107.95 98.63,107.91 99.15,107.39 99.15,106.86 98.97,106.67 98.97,106.38 98.99,106.3 98.99,106.02 98.97,105.94 98.97,105.73 99.12,105.38 99.12,105.29 CPU1.BL3
  BOTTOM w0.114: 98.63,107.95 97.62,108.96 97.62,110.31 96.93,110.99 96.93,112.15 96.68,112.4 96.27,112.4 v2(96.04,112.62) ; C6311.2 27.57,36.13 27.57,38.07 27.42,38.23 27.13,38.23 v2(26.93,38.03)
SSD_PCIE_TX_P16: length 143.7
  L6 w0.102: v2(24.9,38.66) 25.14,38.42 25.33,38.42 25.45,38.55 25.45,49.34 27.81,51.69 30.57,51.69 31.61,52.73 33.5,52.73 38.61,57.85 38.61,59.51 39.86,60.76 39.86,62.62 41.52,64.29 43.44,64.29 49.63,70.49 51.24,70.49 52.37,71.62 52.37,76.02 56.95,80.59 56.95,82.23 56.26,82.92 56.26,89.42 54.23,91.45 54.23,94.74 56.65,97.16 63.6,97.16 64.09,97.65 64.09,102.67 72.51,111.09 91.84,111.09 94.24,113.49 96.8,113.49 97.27,113.02 97.27,111.05 96.14,109.92 v2(96.09,109.92)
  BOTTOM w0.076: 97.48,107.81 97.52,107.81 97.77,107.56 97.77,107.06 98.16,106.67 98.16,106.38 98.13,106.3 98.13,106.02 98.16,105.94 98.16,105.73 98.06,105.51 97.91,105.35 CPU1.BJ3
  BOTTOM w0.114: v2(96.09,109.92) 96.3,110.13 96.48,110.13 96.62,109.99 96.62,108.67 97.48,107.81 ; v2(24.9,38.66) 24.72,38.48 24.29,38.48 24.03,38.22 24.03,36.84 24.58,36.29 24.58,35.8 C6302.2
SSD_SATA_TX_CON_N16: length 2.3
  BOTTOM w0.114: SSD1.47 24.95,33.3 24.81,33.43 24.81,34.36 C6303.1
SSD_SATA_TX_CON_P16: length 2.3
  BOTTOM w0.114: SSD1.49 24.45,33.3 24.59,33.43 24.59,34.35 C6302.1
SSD_SCP#: length 69.8
  TOP w0.089: U2401.21 24.76,64.49 v2(24.88,64.61) ; v2(22.81,27.31) v1(22.61,26.72)
  L5 w0.089: v2(24.88,64.61) 24.88,64.36 22.88,62.36 22.88,61.74 22.46,61.32 21.26,61.32 16.44,56.51 16.44,50.19 16.65,49.98 16.65,49.98 16.86,49.77 16.86,49.77 16.96,49.67 17.07,49.56 17.07,36.21 17.55,35.73 17.55,32.49 22.73,27.31 v2(22.81,27.31)
  BOTTOM w0.089: SSD1.8 34.7,22.07 32.29,19.66 25.64,19.66 24.6,20.7 24.6,22.7 24.57,22.72 24.57,23.48 24.28,23.78 22.48,23.78 21.88,24.38 21.88,25.89 22.81,26.82 v2(22.81,27.31)
SSEQ0_A0: length 3.8
  TOP w0.089: U7101.11 24.61,104.39 24.62,104.4 v2(24.65,104.4)
  BOTTOM w0.089: R7146.1 23.83,104.19 23.42,103.79 v1(23.42,103.46) 24.13,103.46 R7145.2 24.65,103.97 v2(24.65,104.4)
SSEQ1: length 4.7
  TOP w0.089: R7152.2 20.65,101.36 v2(21.09,101.79) 21.4,102.11 U7101.3
  BOTTOM w0.089: R7144.1 21.64,102.13 v1(21.64,102.08) 21.64,101.92 21.52,101.79 v2(21.09,101.79)
ST_GPIO: length 3.5
  TOP w0.089: U9103.6 162.74,83.56 162.23,84.08 160.61,84.08 TP9103.1
ST_PP: length 4.3
  TOP w0.089: U9103.7 162.24,83.63 162,83.87 160.91,83.87 160.05,83.01 158.91,83.01 TP9101.1
STRAP0: length 5.6
  BOTTOM w0.089: R7919.2 128.93,115.43 v1(129.47,115.97) 129.88,115.97 R7908.1 130.41,115.65 130.41,116.86 131.88,118.33 GPU1.D1
STRAP1: length 7.8
  BOTTOM w0.089: GPU1.D2 131.94,119.11 131.37,118.54 131.37,118.18 129.93,116.74 128.02,116.74 v1(127.82,116.54) ; R7909.2 128.3,116.05 v1(127.82,116.54) ; v1(127.82,116.54) 126.93,116.54 R7911.1
STRAP2: length 8.8
  BOTTOM w0.089: GPU1.E4 132.97,120.34 132.65,120.02 132.65,119.4 132.8,119.25 132.8,118.87 130.88,116.95 v1(130.88,114.77) 131.42,114.22 R7914.2 R7915.1
STRAP3: length 10.6
  BOTTOM w0.089: R7977.2 R7926.1 125.3,116.43 v1(125.56,116.69) 125.79,116.92 129.63,116.92 131.15,118.43 131.15,118.63 131.86,119.35 131.99,119.35 132.41,119.77 GPU1.E3
STRAP4: length 10.1
  BOTTOM w0.089: GPU1.D3 133.01,119.12 133.94,118.19 133.94,117.81 133.73,117.6 133.73,115.7 134.39,115.04 134.39,112.98 R7929.1 135.09,112.28 135.09,112.23 135.18,112.14 v1(135.18,111.74) 135.18,111.74 R7976.2
STRAP5: length 7
  BOTTOM w0.089: GPU1.C1 132.18,117.72 132.18,116.23 133.51,114.91 v1(133.51,112.5) R7945.2
STRAP5_R: length 5.1
  BOTTOM w0.089: R7939.1 132.72,112.42 132.29,111.99 132.29,111.28 R7945.1 131.88,111.25 131.24,111.89 131.24,112.02 v1(131.25,112.02) 131.1,112.17 130.46,112.17 R7978.2
STRAP_REF0_GND_N9: length 2.5
  TOP w0.089: R7907.2 135.28,122.05 134.94,122.39 134.79,122.55 v1(134.68,122.55) 134.67,122.55 134.17,122.55 v2(134.12,122.61)
  BOTTOM w0.089: v2(134.12,122.61) 134.12,122.61 134.08,122.64 GPU1.F6
SUS_CLK: length 128.2
  TOP w0.114: v2(59.57,74.22) 60,73.78 63.77,73.78 66.56,70.99 101.9,70.99 103.14,72.23 103.14,76.49 EC1803.2 103.05,76.58 103.05,80.37 103.59,80.91 103.59,85.52 102.6,86.51 v2(102.6,87.15) ; v1(16.78,64.76) 16.54,65 v2(16.23,65) ; R2461.1 21.79,77.42 v2(21.53,77.16)
  L5 w0.114: v2(16.23,65) 16.31,65.08 16.31,67.93 19.17,70.79 19.17,74.65 20.67,76.14 20.67,76.66 21.17,77.16 v2(21.53,77.16)
  BOTTOM w0.114: v2(102.6,87.15) 102.47,87.15 CPU1.BT32 ; v2(59.57,74.22) 54.84,74.22 52.84,72.21 50.97,72.21 50.64,71.88 49.61,71.88 49.41,72.08 48.42,72.08 47.76,72.74 37.85,72.74 37.47,72.36 37.47,72.14 36.75,71.42 35.3,71.42 33.07,69.19 32.94,69.19 32.33,68.59 32.33,68.46 29.86,65.99 26.88,65.99 26.69,65.8 25.64,65.8 25.42,66.02 24.99,66.02 24.71,66.3 22.35,66.3 22.1,66.04 22.09,66.04 21.82,65.78 20.67,65.78 20.43,66.02 19.09,66.02 18.75,65.68 18.13,65.68 17.45,65 v2(16.23,65) ; R6117.1 22.34,77.97 v2(21.53,77.16)
SUSACK#_R: length 99
  TOP w0.114: R1708.2 135.68,68.05 136.74,68.05 v1(136.76,68.07) 136.78,68.05 142.82,68.05 145.24,65.62 148.45,65.62 148.66,65.83 152.62,65.83 153.23,65.22 153.23,60.45 155.93,57.75 156.36,57.75 v2(156.77,58.17)
  L6 w0.114: v2(156.77,58.17) 156.77,57.68 156.64,57.55 129.27,57.55 116.92,69.9 116.92,71.3 108.78,79.43 108.78,83.15 106.2,85.73 106.2,86.41 v2(105.42,87.19)
  BOTTOM w0.114: v2(105.42,87.19) 105.28,87.19 CPU1.BY32
SUSCLK_WLAN: length 80.9
  TOP w0.114: v1(16.63,65.97) 16.85,65.97 v2(17.15,66.27)
  L5 w0.114: v2(21.11,76.48) 21.11,76.07 19.52,74.48 19.52,69.74 17.61,67.82 17.61,66.73 v2(17.15,66.27)
  L6 w0.114: v2(43.18,103.53) 42.45,102.8 42.45,94.9 44.95,92.41 46.21,92.41 47.83,90.78 47.83,86.66 46.02,84.84 45.92,84.84 44.91,83.83 44.91,81.78 43.79,80.66 43.79,74.8 40.14,71.15 39.23,71.15 38.34,70.26 34.55,70.26 34.04,69.75 31.83,69.75 31.58,69.5 29.98,69.5 v2(29.49,69.99)
  BOTTOM w0.114: v2(43.18,103.53) 43.2,103.55 WLAN1.50 ; v2(21.11,76.48) 21.63,76.48 R6117.2 ; v2(29.49,69.99) 29.49,68.76 28.65,67.92 24.97,67.92 24.37,67.32 22.72,67.32 22.4,67.64 20,67.64 19.95,67.59 19.44,67.08 18.11,67.08 17.78,66.76 17.29,66.27 v2(17.15,66.27)
SVID_ALERT#_CPU: length 91.4
  TOP w0.114: PR4605.2 81.38,152.6 R704.2 79.28,153.94 v2(79.28,154.87)
  L3 w0.089: v2(55.68,121.67) 55.68,121.31 55.48,121.11 55.48,120.72 58.69,117.51 61.48,117.51 62.75,116.25 62.75,112.21 64.09,110.87 64.65,110.87 v2(64.7,110.92)
  L5 w0.114: v2(79.28,154.87) 77.98,153.57 76.35,153.57 76.35,153.57 76.06,153.57 72.76,150.26 69.32,150.26 67.78,148.73 67.78,145.78 67.24,145.24 67.24,143.88 64.43,141.06 64.43,140.23 62.34,138.14 58.15,138.14 57.11,137.1 57.11,136.82 57.11,134.15 53.09,130.12 53.09,123.98 54.89,122.18 55.17,122.18 v2(55.68,121.67) ; v2(64.7,110.92) 64.95,110.59 65.12,110.43 67.28,110.43 69.81,112.95 73.02,112.95 73.74,113.67 78.07,113.67 v2(79.42,112.32)
  BOTTOM w0.114: v2(79.42,112.32) 79.38,112.36 79.38,113.59 79.07,113.89 R703.1 ; PR4623.1 v2(79.28,154.87) ; v1(55.35,121.18) 55.68,121.51 v2(55.68,121.67)
SVID_ALERT#_CPU_R: length 8.9
  BOTTOM w0.076: CPU1.AA3 80.87,105.24 81.07,105.7 81.07,105.98 81.07,105.99 80.92,106.13 80.77,106.13 80.57,106.34 80.57,107.61
  BOTTOM w0.114: 80.57,107.61 80.57,108.34 79.25,109.65 79.25,111.69 v1(78.87,112.07) R703.2
SVID_ALERT#_VR: length 2
  BOTTOM w0.114: PR4623.2 79.28,153.19 79.53,152.94 PU4601.36
SVID_CLK_CPU: length 91.8
  TOP w0.114: v2(80.06,154.79) 81.23,153.62 81.71,153.62 82.16,153.18 R705.2 82.93,152.6 PR4606.2
  L3 w0.089: v2(65.36,110.87) 65.36,111.15 65.05,111.46 64.02,111.46 63.01,112.47 63.01,116.36 61.6,117.77 58.8,117.77 55.82,120.76 55.82,121.04 56.32,121.54 v2(56.32,121.67)
  L5 w0.114: v2(56.32,121.67) 55.45,122.53 55.07,122.53 53.43,124.17 53.43,129.98 57.46,134.01 57.46,136.96 58.3,137.8 62.49,137.8 64.77,140.08 64.77,140.37 64.77,140.92 67.59,143.73 67.59,145.1 68.13,145.64 68.13,148.58 69.46,149.92 72.9,149.92 76.21,153.23 78.5,153.23 v2(80.06,154.79) ; v2(80.29,112.29) 78.56,114.02 73.61,114.02 72.89,113.31 69.26,113.31 66.72,110.77 65.46,110.77 v2(65.36,110.87)
  BOTTOM w0.114: v2(80.29,112.29) 80.01,112.01 R702.2 ; PR4624.1 v2(80.06,154.79) ; v2(56.32,121.67) v1(56.78,121.98)
SVID_CLK_CPU_R: length 4.6
  BOTTOM w0.076: 80.81,107.65 80.81,107.65 80.81,106.49 CPU1.AA1
  BOTTOM w0.114: 80.81,107.65 80.81,108.6 80.01,109.4 v1(80.01,109.78) R702.1
SVID_CLK_VR: length 1.9
  BOTTOM w0.114: PU4601.37 79.93,152.29 79.96,152.33 v1(79.96,152.34) 79.99,152.36 79.99,153.14 PR4624.2
SVID_DATA_CPU: length 89.2
  TOP w0.114: R706.2 79.82,152.6 PR4604.2 78.49,153.16 v2(78.49,154.87) ; v2(55.02,121.64) v1(55.4,121.19)
  L3 w0.089: v2(64.27,110.34) 63.93,110.34 61.8,112.47 61.8,112.91 62.48,113.59 62.48,116.13 61.37,117.24 58.58,117.24 55.15,120.68 55.15,121.14 55.02,121.26 v2(55.02,121.64)
  L5 w0.114: v2(78.34,112.29) 77.52,113.11 73.99,113.11 73.33,112.45 70.19,112.45 67.83,110.08 64.52,110.08 v2(64.27,110.34) ; v2(78.49,154.87) 77.54,153.91 76.49,153.91 75.92,153.91 72.61,150.6 69.61,150.6 69.61,150.6 69.18,150.6 67.44,148.87 67.44,145.92 66.9,145.38 66.9,144.02 64.09,141.21 64.09,140.37 62.2,138.48 58.01,138.48 56.77,137.24 56.77,136.67 56.77,134.29 52.68,130.2 52.68,123.83 54.71,121.79 54.87,121.79 v2(55.02,121.64)
  BOTTOM w0.114: PR4622.1 v2(78.49,154.87) ; v2(78.34,112.29) 77.85,111.81 R701.2
SVID_DATA_CPU_R: length 6.8
  BOTTOM w0.114: CPU1.AA2 80.61,105.83 80.35,106.09 80.35,108.18 78.87,109.65 78.87,110.62 v1(78.74,110.75) R701.1
SVID_DATA_VR: length 2.2
  BOTTOM w0.114: PR4622.2 78.51,153.21 79.13,152.6 PU4601.35
SW_PIN: length 3.1
  TOP w0.089: U5802.18 53.7,115.06 53.91,114.85 53.91,114.34 v2(53.98,114.28) 54.49,114.28 v1(54.59,114.38)
  BOTTOM w0.089: v2(53.98,114.28) 53.95,114.3 53.95,114.73 53.67,115.01 R5820.2
SYS_LED_MASK#: length 90.5
  TOP w0.089: v2(32.26,66.27) 32.53,66 32.53,65.71 32.53,65.71 32.53,61.37 33.95,59.95 U2401.55 ; v1(21.03,62.31) 21.03,61.9 20.59,61.46 Q3201.G 20.17,61.46 R2465.1 19.64,61.82 19,61.82 v2(18.67,62.16) ; Q6402.G 45.23,59.22 43.26,61.19 43.26,63.3 45.29,65.33 46.05,65.33 46.49,65.76 46.49,68.73 47.69,69.94 47.69,70.01 v2(47.7,70.01)
  L3 w0.089: v2(27.89,78.33) 23.6,78.33 17.71,72.45 17.71,63.11 v2(18.67,62.16)
  BOTTOM w0.089: v2(27.89,78.33) 27.69,78.13 Q6406.2 Q6406.5 ; v2(18.67,62.16) 19.84,60.99 R2497.1 20.45,61.39 20.45,61.95 21.62,63.12 21.62,63.35 22.2,63.93 24.42,63.93 24.51,63.83 25.76,63.83 26.11,63.48 28.05,63.48 29.87,65.3 30.48,65.3 31.45,66.27 v2(32.26,66.27) 32.26,66.76 34.86,69.37 38.21,69.37 39.75,70.91 46.8,70.91 v2(47.7,70.01)
SYS_PEX_RST_MON#: length 17.5
  TOP w0.089: v1(134.79,98.06) 134.6,97.87 134.6,97.23 v2(134.99,96.85)
  L5 w0.089: v2(134.99,96.85) 134.01,97.82 134.01,100.61 135.74,102.34 v2(136.55,102.34)
  BOTTOM w0.089: R7974.2 137.85,103.63 ; 137.85,103.63 137.85,102.93 R7922.2 137.83,102.55 137.4,102.12 R7613.1 136.94,101.19 136.35,101.19 135.77,101.78 U7602.2 ; 137.85,103.63 v2(136.55,102.34) ; U7601.4 135.4,95.8 R7606.1 v2(134.99,96.85)
SYS_PEX_RST_MON_GPU#: length 22.4
  L6 w0.089: v2(136.51,123.76) 136.51,121.86 137.32,121.05 137.32,117.69 137.85,117.16 137.85,106.05 138.01,105.89 138.48,105.89 138.73,105.64 138.73,105.16 139,104.89 v2(139,104.83)
  BOTTOM w0.089: R7974.1 138.74,103.78 v1(139.43,104.47) 139.07,104.83 v2(139,104.83) ; GPU1.E9 v2(136.51,123.76)
SYS_PRES1#: length 8.7
  TOP w0.089: v2(138.56,35.23) 138.56,34.49 AFTP4315.1 137.62,33.55 135.79,33.55 R4301.2
  BOTTOM w0.089: v2(138.56,35.23) 138.81,35.49 138.81,36.07 137.82,37.06 BATT1.7
SYS_PWROK: length 211
  TOP w0.089: v2(24.77,61.65) 24.72,61.69 U2401.28 ; v2(116.82,100.88) 117.32,100.38 118.44,100.38 119.64,99.18 119.64,96.77 122.74,93.67 122.74,91.52 124.62,89.64 124.62,70.37 109.95,55.7 98.43,55.7 98.17,55.96 56.54,55.96 50.73,50.14 50.73,41.83 51.2,41.36 v1(51.24,41.36) 51.55,41.04 51.55,34.15 51.21,33.81 36.61,33.81 v2(36.44,33.98)
  L5 w0.089: v2(24.77,61.65) 24.45,61.32 24.42,61.32 18.67,55.58 18.67,50.33 17.95,49.61 17.95,36.69 19.19,35.46 19.19,32.11 22.5,28.8 29.2,28.8 29.26,28.87 29.85,28.87 29.85,28.87 30.48,28.87 35.3,33.69 35.3,34.11 35.55,34.36 36.06,34.36 v2(36.44,33.98)
  BOTTOM w0.076: 114.96,100.84 114.23,100.84 114.2,100.86 CPU1.CR10
  BOTTOM w0.089: 114.96,100.84 115.17,100.84 115.27,100.73 116.55,100.73 116.65,100.83 116.77,100.83 v2(116.82,100.88) ; R1717.1 22.34,60.48 ED1702.2 23.05,61.19 24.31,61.19 v2(24.77,61.65)
SYSPWR_PRES: length 4
  TOP w0.089: v2(28.42,72.9) 28.36,72.96 U2401.120
  BOTTOM w0.089: R2463.2 27.77,74.61 R2454.1 ; R2463.2 27.08,73.89 v1(26.88,73.69) ; R2463.2 28.42,73.23 v2(28.42,72.9)
T_CRIT#: length 6.4
  TOP w0.089: R2604.2 124.27,113.18 123.17,113.18 122.61,113.74 R2601.1 v1(122.08,114.92) 122.08,115.67 122.2,115.8 122.2,116.3 U2601.4
TESTMODE: length 7.9
  TOP w0.089: v2(124.75,134.32) 124.75,134.92 v1(124.75,134.93)
  L5 w0.089: v2(120.63,138.12) 120.63,137.95 123.79,134.79 123.79,134.78 124.03,134.55 124.03,134.55 124.26,134.31 124.74,134.31 v2(124.75,134.32)
  BOTTOM w0.089: v2(120.63,138.12) 120.72,138.21 R7602.1 ; GPU1.AD9 124.79,134.36 v2(124.75,134.32)
THERM_SYS_SHDN#: length 14.3
  TOP w0.089: v2(123.7,113.62) 123.38,113.62 R2601.2 ; v2(128.02,106.31) 128.02,106.53 127.16,107.39 v1(127.16,108.03) 126.27,108.91 126.27,110.85 126.68,111.25 v2(126.83,111.25)
  BOTTOM w0.089: v2(126.83,111.25) 125.92,111.25 Q2602.S 125.59,110.97 124.08,110.97 123.07,111.98 123.07,112.99 v2(123.7,113.62) ; R2602.1 128.65,105.47 128.02,106.1 v2(128.02,106.31)
THERMTRIP#_CPU: length 12.6
  L5 w0.089: v2(92.64,113.44) 95,111.08 95,109.02 95.38,108.64 v2(96.14,108.64)
  BOTTOM w0.089: v2(92.64,113.44) 92.36,113.72 v1(92.05,113.72) 92.33,114 R308.2 92.23,114.68 ED301.1 ; v2(96.14,108.64) 97.41,107.37 97.41,106.94 97.86,106.48 CPU1.BJ1
TOP_MUX_N: length 24.8
  TOP w0.114: v1(12.6,122.1) 12.3,121.8 v2(12.3,121.57) ; EL7105.3 27.62,118.15 27.47,118 27.03,118 26.54,118.49 26.22,118.49 v2(26.03,118.68) ; R7333.2 v2(10.49,123.34)
  L6 w0.102: v2(12.3,121.57) 12.3,120.76 12.61,120.45 22.53,120.45 24.54,118.44 25.8,118.44 v2(26.03,118.68)
  BOTTOM w0.114: v2(12.3,121.57) 12.28,121.57 11.84,122 11.66,122 ED7311.2 11.15,122.63 10.49,123.29 v2(10.49,123.34) 10.03,123.8 8.21,123.8 8.06,123.95 JUSB1.A7
TOP_MUX_N_L: length 3.1
  TOP w0.114: U7102.17 31.21,118.79 31.09,118.67 30.85,118.67 30.58,118.41 30.58,118.08 30.42,117.91 30.27,117.91 R7131.2 30,118.15 EL7105.4
TOP_MUX_P: length 24.9
  TOP w0.114: EL7105.2 27.61,117.47 27.31,117.77 26.94,117.77 26.44,118.26 26.27,118.26 v2(26.04,118.04) ; v1(11.38,122.07) 11.66,121.79 v2(11.66,121.57) ; v2(9.86,123.34) 9.86,122.86 R7332.2
  L6 w0.102: v2(26.04,118.04) 25.83,118.24 24.45,118.24 22.45,120.24 12.53,120.24 12.09,120.68 12.09,120.97 11.97,121.1 11.79,121.1 11.66,121.23 v2(11.66,121.57)
  BOTTOM w0.114: v2(11.66,121.57) 11.66,121.67 11.32,122.02 10.92,122.02 10.54,122.4 ED7312.2 10.54,122.66 v2(9.86,123.34) 9.63,123.57 8.21,123.57 8.08,123.45 JUSB1.A6
TOP_MUX_P_L: length 3.1
  TOP w0.114: U7102.18 31.21,118.39 31.16,118.44 30.94,118.44 30.81,118.31 30.81,117.98 30.51,117.68 30.27,117.68 R7132.2 29.98,117.47 EL7105.1
TOUCH_I2C_DET#: length 148.8
  TOP w0.089: AFTP5501.1 168.41,72.38 v2(168.39,72.39)
  L3 w0.089: v2(107.18,89.13) 107.63,89.58 108.57,89.58 109.96,88.19 111.42,88.19 113.33,86.27 115.23,86.27 115.76,85.75 117.55,85.75 118.26,86.45 122.18,86.45 123.55,85.08 123.55,79.22 126.34,76.43 v2(127.54,76.43) ; v2(219.71,51.55) 220.27,52.11 220.27,57.71 219.91,58.07 218.65,58.07 215.88,60.83 215.88,62.98 215.5,63.37 199.56,63.37 197.64,61.45 184.77,61.45 181.98,64.24 181.98,67.36 179.35,70 178.37,70 v2(177.36,71)
  L6 w0.089: v2(168.39,72.39) 168.42,72.37 173.06,72.37 173.97,71.45 176.81,71.45 177.26,71 v2(177.36,71)
  BOTTOM w0.089: v2(168.39,72.39) 168.39,74.41 167.36,75.44 160.97,75.44 160.63,75.11 160.31,74.78 129.19,74.78 v2(127.54,76.43) ; v2(219.71,51.55) LCD1.12 217.41,51.55 216.79,50.93 R2062.2 ; v2(107.18,89.13) 106.85,88.8 CPU1.CC29
TOUCH_PAD_INTR#: length 7.4
  BOTTOM w0.089: CPU1.CB34 106.34,85.39 105.8,84.85 105.62,84.85 105.43,84.66 105.43,84.09 105.24,83.9 v1(105.24,81.98) 105.24,81.58 106.2,80.62 106.2,79.8 R319.2
TOUCH_PANEL_INTR#: length 5.1
  TOP w0.089: v2(114.07,105.06) 113.92,105.21 v1(113.36,105.21) 112.53,104.38 R5533.1 112.53,103.66 R5544.2
  BOTTOM w0.089: v2(114.07,105.06) 113.45,105.06 113.24,105.27 113.24,105.3 113.05,105.49 112.5,105.49 CPU1.CN3
TOUCH_PANEL_PD#: length 149.1
  TOP w0.089: v2(178.25,71.05) 178.06,70.86 AFTP5503.1
  L3 w0.089: v2(178.25,71.05) 178.13,70.93 178.13,70.49 178.44,70.17 179.42,70.17 182.16,67.44 182.16,64.31 184.84,61.63 197.57,61.63 199.49,63.55 215.57,63.55 216.06,63.05 216.06,60.91 218.72,58.24 219.98,58.24 220.72,57.5 220.72,50.77 220.5,50.55 v2(219.71,50.55)
  BOTTOM w0.076: CPU1.CC35 106.88,85.04 106.88,84.79 106.76,84.67 106.74,84.62 106.74,84.39 106.76,84.34 106.76,84.33 106.76,84.03 106.76,84.02 106.74,83.97 106.74,83.57 106.76,83.55 106.76,83.38
  BOTTOM w0.089: LCD1.14 v2(219.71,50.55) ; 106.76,83.38 106.76,82.33 106.99,82.1 106.99,81.22 107.39,80.81 107.39,76.72 112.18,71.93 112.33,71.93 114.58,71.93 117.35,71.93 119.97,69.32 132.56,69.32 132.78,69.1 134.43,69.1 136.2,70.87 144.96,70.87 145.56,70.28 155.51,70.28 158.16,67.63 174.85,67.63 178.25,71.03 v2(178.25,71.05)
TOUCH_REPORT_SW: length 108.1
  TOP w0.089: AFTP5514.1 137.21,35.46 v2(137.44,35.23)
  L5 w0.089: v2(137.44,35.23) 138.08,34.6 142.37,34.6 142.38,34.6 147.66,34.6 148.28,33.99 150.32,33.99 151.06,34.73 162.57,34.73 162.7,34.6 170.23,34.6 170.84,33.99 184.15,33.99 185.58,35.41 186.1,35.41 190.29,39.6 192.59,39.6 193.38,38.81 199.19,38.81 199.57,38.43 203.1,38.43 203.1,38.43 204.51,38.43 205.22,37.73 207.93,37.73 208.6,38.4 211.44,38.4 213.61,40.57 217.8,40.57 219.17,39.2 219.17,37.94 219.97,37.14 220.63,37.14 220.98,37.49 220.98,42.5 v2(220.2,43.28)
  BOTTOM w0.089: v2(220.2,43.28) 220.2,44.02 219.73,44.48 219.67,44.48 219.6,44.55 LCD1.26 ; v2(137.44,35.23) 137.44,35.59 137.14,35.89 134.37,35.89 133.02,37.24 D2402.A
TOUCH_USB20_N: length 171.2
  TOP w0.114: v1(214.52,46.45) 214.52,46.88 v3(214.38,47.02) 214.2,47.19 213.79,47.19 R5511.1
  L5 w0.102: v3(214.38,47.02) 214.63,47.27 215.4,47.27 215.65,47.52 215.65,49.91 219.21,53.47 219.97,53.47 221.24,54.73 221.24,58.68 220.33,59.59 218.09,59.59 216.49,61.19 207.23,61.19 205.76,59.72 191.54,59.72 189.91,58.09 182.86,58.09 178.79,62.16 178.79,62.18 177.7,63.27 177.7,63.88 175.36,66.22 172.4,66.22 170.97,67.64 160.16,67.64 159.99,67.8 131.83,67.8 125.83,73.8 125.83,93.29 122.84,96.29 122.84,101.48 122.64,101.68 122.64,101.98 119.82,104.8 117.22,104.8 116.18,105.84 116.18,107.07 v2(116.42,107.32)
  L6 w0.102: v2(110.19,103.48) 109.96,103.71 109.96,104.67 111.56,106.26 112.54,106.26 113.59,107.32 114.55,107.32 115.32,106.54 116.14,106.54 116.42,106.82 v2(116.42,107.32)
  BOTTOM w0.114: CPU1.CH5 109.88,103.79 v2(110.19,103.48)
TOUCH_USB20_N_R: length 13.8
  TOP w0.114: 211.38,47.19 210.93,47.19 v2(210.74,47.01) ; 211.38,47.19 212.37,47.19 R5511.2 ; 211.38,47.19 v1(211.38,47.06)
  BOTTOM w0.114: LCD1.28 218.28,43.55 218.15,43.69 217.74,43.69 216.74,44.69 216.74,46.03 216.21,46.56 215.07,46.56 214.81,46.31 213.93,46.31 213.67,46.57 213.67,47.26 213.48,47.45 213.2,47.45 ED5502.4 212.72,47.45 212.47,47.45 212.31,47.3 211.03,47.3 v2(210.74,47.01)
