# Allegro board 17931-1.1228WZS1336.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ14: length 58.1
  L5 w0.114: v2(116.05,47.76) 116.04,47.76 115.24,48.55 115.24,50.2 103.07,62.37 101.16,62.37 97.97,65.56 97.97,65.74 98.71,66.47 98.71,66.63 98.54,66.8 98.38,66.8 97.76,66.17 97.6,66.17 97.44,66.33 97.44,66.49 98.06,67.12 98.06,67.28 97.9,67.44 97.74,67.44 97.11,66.82 96.95,66.82 96.79,66.98 96.79,67.14 97.41,67.77 97.41,67.93 97.25,68.09 97.09,68.09 96.47,67.46 96.3,67.46 96.14,67.63 96.14,67.79 96.77,68.41 96.77,68.57 94.31,71.03 94.31,78.06 v2(92.38,79.99)
  BOTTOM w0.076: CPU1.AW36 91.89,84.45 92.14,83.99 92.14,83.68 91.9,83.44 91.9,82.8 91.92,82.78 91.92,82.75 91.99,82.68 91.99,82.67 92.02,82.65 92.02,80.35 92.08,80.29
  BOTTOM w0.114: 92.08,80.29 v2(92.38,79.99) ; v2(116.05,47.76) 116.53,48.23 DM2.41
M_B_DQ15: length 58
  L5 w0.114: v2(92.37,79.34) 93.96,77.75 93.96,69.08 94.21,68.84 94.37,68.84 95.1,69.57 95.28,69.57 95.43,69.41 95.43,69.25 94.69,68.51 94.69,68.35 94.85,68.19 95.01,68.19 95.75,68.93 95.93,68.93 96.08,68.77 96.08,68.61 95.34,67.87 95.34,67.71 101.02,62.03 102.93,62.03 114.9,50.05 114.9,47.61 115.16,47.35 115.84,47.35 115.87,47.32 116.5,47.32 v2(116.57,47.39)
  BOTTOM w0.076: v2(92.37,79.34) 91.85,79.86 91.85,82.55 91.8,82.6 91.8,82.6 91.74,82.67 91.74,83.7 CPU1.AW37
  BOTTOM w0.114: DM2.42 116.67,43.01 116.67,47.3 v2(116.57,47.39)
M_B_DQ16: length 63.7
  L5 w0.076: v2(86.23,89.17) 85.71,88.66 85.71,88.38 85.68,88.34 85.68,87.67 85.63,87.63
  L5 w0.114: v2(117.61,46.95) 117.01,47.55 117.01,47.57 116.49,48.09 116.49,50.17 95.53,71.14 95.53,72.9 95.53,73.55 95.4,73.68 95.4,78.55 92.82,81.12 91.69,81.12 90.61,82.2 89.12,82.2 87.54,83.78 86.89,83.78 85.56,85.11 84.78,85.11 84.53,85.36 84.53,85.7 84.79,85.95 84.79,86.78 85.63,87.63
  BOTTOM w0.114: v2(117.61,46.95) 117.62,46.95 117.78,46.8 DM2.46 ; CPU1.AJ29 v2(86.23,89.17)
M_B_DQ17: length 62.8
  L5 w0.076: 85.78,87.34 85.86,87.43 85.86,88.17 v2(86.23,88.54)
  L5 w0.114: v2(117.55,48.31) 117.54,48.31 117.23,48.01 117.06,48.01 116.83,48.24 116.83,48.72 116.95,48.84 116.97,48.84 117.09,48.95 117.09,49.18 116.97,49.29 116.95,49.29 116.83,49.41 116.83,50.32 99.68,67.47 99.68,67.63 99.7,67.66 99.7,67.82 99.54,67.98 99.38,67.98 99.35,67.96 99.19,67.96 99.03,68.12 99.03,68.28 99.06,68.3 99.06,68.46 98.89,68.63 98.73,68.63 98.71,68.6 98.55,68.6 98.38,68.76 98.38,68.93 98.41,68.95 98.41,69.11 98.25,69.27 98.09,69.27 98.06,69.25 97.9,69.25 97.74,69.41 97.74,69.57 97.76,69.6 97.76,69.76 97.6,69.92 97.44,69.92 97.41,69.9 97.25,69.9 97.09,70.06 97.09,70.22 97.12,70.24 97.12,70.4 96.95,70.57 96.79,70.57 96.77,70.54 96.61,70.54 95.87,71.28 95.87,73.04 95.87,73.04 95.87,73.63 95.61,73.88 95.61,78.66 92.94,81.34 91.78,81.34 90.7,82.42 89.21,82.42 87.63,84 86.98,84 85.49,85.49 85.49,85.59 85.05,86.03 85.05,86.61 85.78,87.34
  BOTTOM w0.114: DM2.49 118.53,48.34 118.4,48.21 117.65,48.21 v2(117.55,48.31) ; CPU1.AJ30 v2(86.23,88.54)
M_B_DQ18: length 63.3
  L5 w0.076: v2(88.09,87.15) 88.09,86.91 88.46,86.54 88.46,86.25 88.44,86.23 88.44,86.08
  L5 w0.114: v2(120.91,49.07) 120.91,49.94 120.62,50.23 120.62,50.3 113.34,57.57 113.34,57.73 113.47,57.86 113.47,58.02 113.31,58.18 113.15,58.18 113.02,58.06 112.86,58.06 112.7,58.22 112.7,58.38 112.82,58.51 112.82,58.67 112.66,58.83 112.5,58.83 112.37,58.7 112.21,58.7 112.05,58.87 112.05,59.03 112.18,59.15 112.18,59.31 112.02,59.48 111.85,59.48 111.73,59.35 111.57,59.35 111.4,59.51 111.4,59.67 111.53,59.8 111.53,59.96 111.37,60.12 111.21,60.12 111.08,60 110.92,60 110.76,60.16 110.76,60.32 110.88,60.45 110.88,60.61 110.72,60.77 110.56,60.77 110.43,60.64 110.27,60.64 110.11,60.81 110.11,60.97 110.24,61.09 110.24,61.25 110.08,61.42 109.91,61.42 109.79,61.29 109.63,61.29 109.46,61.45 109.46,61.61 109.59,61.74 109.59,61.9 109.43,62.06 109.27,62.06 109.14,61.94 108.98,61.94 108.82,62.1 108.82,62.26 108.94,62.39 108.94,62.55 108.78,62.71 108.62,62.71 108.49,62.58 108.33,62.58 108.17,62.75 108.17,62.91 108.3,63.03 108.3,63.19 108.14,63.36 107.97,63.36 107.85,63.23 107.69,63.23 107.52,63.39 107.52,63.55 107.65,63.68 107.65,63.84 107.49,64 107.33,64 107.2,63.88 107.04,63.88 106.88,64.04 106.88,64.2 107,64.33 107,64.49 106.84,64.65 106.68,64.65 106.55,64.52 106.39,64.52 106.23,64.69 106.23,64.85 106.36,64.97 106.36,65.13 106.2,65.3 106.03,65.3 105.91,65.17 105.75,65.17 105.6,65.32 105.6,65.5 105.71,65.61 105.71,65.79 98.42,73.08 98.42,73.21 98.4,73.23 98.4,78.59 97.78,79.21 97.78,80.09 95.65,82.22 94.34,82.22 92.99,83.57 91.72,83.57 91.09,84.2 89.74,84.2 88.44,85.5 88.44,86.08
  BOTTOM w0.114: v2(120.91,49.07) 121.03,49.19 DM2.59 ; CPU1.AM32 87.91,87.17 88.07,87.17 v2(88.09,87.15)
M_B_DQ19: length 64
  L5 w0.076: 87.65,86.86 87.68,86.89 87.68,87.5 v2(88.01,87.83)
  L5 w0.114: 87.65,86.86 87.65,86.17 88.14,85.69 88.14,85.5 89.65,83.98 91,83.98 92.31,82.67 93.58,82.67 94.25,82.01 95.56,82.01 97.56,80 97.56,79.13 98.05,78.63 98.05,73.1 98.06,73.09 98.06,73.09 98.07,73.07 98.07,72.94 103.8,67.2 103.8,67.04 103.68,66.91 103.68,66.75 103.84,66.59 104,66.59 104.13,66.72 104.29,66.72 104.45,66.56 104.45,66.39 104.32,66.27 104.32,66.11 104.49,65.94 104.65,65.94 104.77,66.07 104.94,66.07 105.1,65.91 105.1,65.75 104.97,65.62 104.97,65.46 120.27,50.16 120.27,48.13 120.78,47.63 121.44,47.63 122.04,47.03 v2(122.11,47.03)
  BOTTOM w0.114: v2(122.11,47.03) 122.11,46.85 122.11,46.84 122.11,46.76 122.09,46.74 122.09,46.32 121.78,46.01 DM2.62 ; v2(88.01,87.83) 87.93,87.83 CPU1.AM31
M_B_DQ20: length 64.4
  L5 w0.076: 88.66,86.14 88.66,86.66 88.52,86.79 88.52,88.04 v2(88.07,88.5)
  L5 w0.114: 88.66,86.14 88.66,85.59 89.83,84.42 91.17,84.42 91.81,83.78 93.08,83.78 94.43,82.44 95.74,82.44 97.99,80.18 97.99,79.3 98.76,78.54 98.76,73.22 114.05,57.92 114.05,57.76 113.93,57.63 113.93,57.47 114.09,57.31 114.25,57.31 114.38,57.44 114.54,57.44 114.7,57.28 114.7,57.11 114.58,56.99 114.58,56.83 114.74,56.66 114.9,56.66 115.02,56.79 115.19,56.79 115.35,56.63 115.35,56.47 115.22,56.34 115.22,56.18 115.38,56.02 115.55,56.02 115.67,56.14 115.83,56.14 115.99,55.98 115.99,55.82 115.87,55.69 115.87,55.53 116.03,55.37 116.19,55.37 116.32,55.5 116.48,55.5 116.64,55.34 116.64,55.17 116.52,55.05 116.52,54.89 116.68,54.72 116.84,54.72 116.96,54.85 117.13,54.85 117.29,54.69 117.29,54.53 117.16,54.4 117.16,54.24 117.32,54.08 117.49,54.08 117.61,54.2 117.77,54.2 117.93,54.04 117.93,53.88 117.81,53.75 117.81,53.59 117.97,53.43 118.13,53.43 118.26,53.56 118.42,53.56 118.58,53.4 118.58,53.23 118.46,53.11 118.46,52.95 118.62,52.78 118.78,52.78 118.91,52.91 119.07,52.91 119.23,52.75 119.23,52.59 119.1,52.46 119.1,52.3 119.26,52.14 119.43,52.14 119.55,52.26 119.71,52.26 119.88,52.1 119.88,51.94 119.75,51.81 119.75,51.65 119.91,51.49 120.07,51.49 120.2,51.62 120.36,51.62 120.52,51.46 120.52,51.29 120.4,51.17 120.4,51.01 120.56,50.84 120.72,50.84 120.85,50.97 121.01,50.97 121.25,50.73 121.25,49.35 121.39,49.21 121.59,49.21 v2(122,49.61)
  BOTTOM w0.114: v2(88.07,88.5) 87.71,88.5 87.59,88.38 CPU1.AM30 ; DM2.63 122.03,49.64 v2(122,49.61)
M_B_DQ21: length 65.3
  L5 w0.076: v2(88.04,89.13) 87.57,88.66 87.57,87.69 87.51,87.63 87.51,87.02 87.44,86.95
  L5 w0.114: v2(121.01,46.99) 120.59,46.99 119.81,47.77 119.81,50.13 103.05,66.9 103.05,67.06 103.17,67.19 103.17,67.35 103.01,67.51 102.85,67.51 102.72,67.38 102.56,67.38 102.4,67.54 102.4,67.71 102.53,67.83 102.53,67.99 102.37,68.16 102.2,68.16 102.08,68.03 101.92,68.03 101.75,68.19 101.75,68.35 101.88,68.48 101.88,68.64 101.72,68.8 101.56,68.8 101.43,68.68 101.27,68.68 100.38,69.57 100.38,70.14 100.36,70.16 100.36,70.16 97.69,72.83 97.69,78.69 97.34,79.04 97.34,79.91 95.47,81.79 94.16,81.79 93.49,82.46 92.22,82.46 90.91,83.77 89.56,83.77 87.92,85.41 87.92,85.6 87.44,86.08 87.44,86.95
  BOTTOM w0.114: CPU1.AM29 87.92,89.13 v2(88.04,89.13) ; v2(121.01,46.99) 121.01,46.42 120.78,46.18 DM2.58
M_B_DQ22: length 61.1
  L5 w0.114: v2(117.53,49.67) 117.62,49.76 117.62,50.3 117.51,50.41 117.22,50.41 112.98,54.65 112.98,54.94 112.62,55.3 112.62,55.38 112.46,55.54 112.3,55.54 112.28,55.52 112.11,55.52 111.95,55.68 111.95,55.84 111.98,55.87 111.98,56.03 111.81,56.19 111.65,56.19 111.63,56.17 111.47,56.17 111.31,56.33 111.31,56.49 111.33,56.51 111.33,56.67 111.17,56.84 111.01,56.84 110.98,56.81 110.82,56.81 110.66,56.97 110.66,57.14 110.68,57.16 110.68,57.32 110.52,57.48 110.36,57.48 110.34,57.46 110.17,57.46 110.01,57.62 110.01,57.78 110.04,57.81 110.04,57.97 109.87,58.13 109.71,58.13 109.69,58.11 109.53,58.11 109.37,58.27 109.37,58.43 109.39,58.45 109.39,58.61 109.23,58.78 109.07,58.78 109.04,58.75 108.88,58.75 108.72,58.91 108.72,59.08 108.74,59.1 108.74,59.26 108.58,59.42 108.42,59.42 108.4,59.4 108.23,59.4 108.07,59.56 108.07,59.72 108.1,59.75 108.1,59.91 107.93,60.07 107.77,60.07 107.75,60.05 107.59,60.05 107.43,60.21 107.43,60.37 107.45,60.39 107.45,60.55 107.29,60.72 107.13,60.72 107.1,60.69 106.94,60.69 106.78,60.85 106.78,61.02 106.8,61.04 106.8,61.2 106.64,61.36 106.48,61.36 106.46,61.34 106.29,61.34 106.13,61.5 106.13,61.66 106.16,61.69 106.16,61.85 105.99,62.01 105.83,62.01 105.81,61.99 105.65,61.99 105.49,62.15 105.49,62.31 105.51,62.33 105.51,62.49 105.35,62.66 105.19,62.66 105.16,62.63 105,62.63 104.84,62.79 104.84,62.96 104.86,62.98 104.86,63.14 104.7,63.3 104.54,63.3 104.52,63.28 104.35,63.28 104.19,63.44 104.19,63.6 104.22,63.63 104.22,63.79 104.05,63.95 103.89,63.95 103.87,63.93 103.71,63.93 103.55,64.09 103.55,64.25 103.57,64.27 103.57,64.43 103.41,64.6 103.25,64.6 103.22,64.57 103.06,64.57 102.9,64.73 102.9,64.9 102.92,64.92 102.92,65.08 102.76,65.24 102.6,65.24 102.58,65.22 102.41,65.22 102.25,65.38 102.25,65.54 102.28,65.57 102.28,65.73 102.11,65.89 101.95,65.89 101.93,65.87 101.77,65.87 101.61,66.03 101.61,66.19 101.63,66.21 101.63,66.37 101.39,66.62 101.23,66.62 101.2,66.59 101.04,66.59 100.88,66.76 100.88,66.92 100.9,66.94 100.9,67.1 100.74,67.26 100.58,67.26 100.56,67.24 100.39,67.24 100.23,67.4 100.23,67.56 100.26,67.59 100.26,67.75 96.21,71.79 96.21,73.63 95.83,74.01 95.83,78.75 93,81.58 91.84,81.58 90.79,82.63 89.3,82.63 87.72,84.21 87.1,84.21 85.7,85.61 85.7,85.74 85.26,86.18 85.26,86.52 86.25,87.51 v2(86.25,87.88)
  BOTTOM w0.114: CPU1.AJ31 86.22,87.88 v2(86.25,87.88) ; DM2.45 v2(117.53,49.67)
M_B_DQ23: length 62.3
  L5 w0.114: v2(118.16,47.75) 118.36,47.56 118.54,47.56 118.69,47.71 118.69,47.9 117.96,48.63 117.96,50.53 117.71,50.78 117.55,50.78 117.53,50.75 117.37,50.75 117.2,50.92 117.2,51.08 117.23,51.1 117.23,51.26 117.07,51.42 116.91,51.42 116.88,51.4 116.72,51.4 116.56,51.56 116.56,51.72 116.58,51.75 116.58,51.91 116.42,52.07 116.26,52.07 116.23,52.05 116.07,52.05 115.91,52.21 115.91,52.37 115.93,52.39 115.93,52.56 115.77,52.72 115.61,52.72 115.59,52.69 115.43,52.69 115.26,52.86 115.26,53.02 115.29,53.04 115.29,53.2 115.13,53.36 114.96,53.36 114.94,53.34 114.78,53.34 114.62,53.5 114.62,53.66 114.64,53.69 114.64,53.85 114.48,54.01 114.32,54.01 114.29,53.99 114.13,53.99 113.97,54.15 113.97,54.31 113.99,54.33 113.99,54.5 113.83,54.66 113.67,54.66 113.65,54.63 113.49,54.63 113.32,54.8 113.32,54.96 113.35,54.98 113.35,55.14 96.56,71.94 96.56,74.37 96.05,74.88 96.05,78.84 93.09,81.8 91.93,81.8 90.88,82.85 89.39,82.85 87.81,84.43 87.19,84.43 85.92,85.7 85.92,86.11 v2(85.67,86.35)
  BOTTOM w0.114: DM2.50 118.78,46.93 118.61,47.31 v2(118.16,47.75) ; v2(85.67,86.35) 85.77,86.45 CPU1.AJ32
M_B_DQ24: length 63.4
  L5 w0.114: v2(124.31,47.83) 124.31,48.23 124.28,48.26 124.28,49.89 106.62,67.55 106.62,69.22 106.38,69.46 106.22,69.46 105.9,69.14 105.74,69.14 105.58,69.3 105.58,69.47 105.89,69.78 105.89,69.94 105.73,70.11 105.57,70.11 105.25,69.79 105.09,69.79 104.93,69.95 104.93,70.11 105.25,70.43 105.25,70.59 102.5,73.34 100.58,73.34 100.16,73.76 100.16,78.02 99.65,78.52 99.65,79.94 96.23,83.36 94.72,83.36 93.42,84.67 92.14,84.67 91.53,85.28 91.46,85.28 89.93,86.82 v2(89.93,87.83)
  BOTTOM w0.114: CPU1.AR31 89.75,87.83 v2(89.93,87.83) ; DM2.71 124.03,50.16 123.85,49.98 123.85,48.68 123.96,48.57 124.17,48.36 124.17,47.97 v2(124.31,47.83)
M_B_DQ25: length 63.2
  L5 w0.114: v2(123.54,47.82) 123.54,48.28 123.83,48.57 123.83,49.86 106.28,67.41 106.28,68.1 104.2,70.18 104.2,70.34 104.32,70.47 104.32,70.63 104.16,70.79 104,70.79 103.88,70.66 103.72,70.66 103.55,70.83 103.55,70.99 103.68,71.11 103.68,71.27 103.52,71.44 103.35,71.44 103.23,71.31 103.07,71.31 102.28,72.1 101.94,72.1 101.71,71.88 101.55,71.88 101.39,72.04 101.39,72.2 101.68,72.49 101.68,72.66 101.52,72.82 101.36,72.82 101.07,72.53 100.91,72.53 99.77,73.66 99.77,78.09 99.44,78.43 99.44,79.65 96,83.08 94.7,83.08 93.33,84.45 92.05,84.45 91.44,85.06 91.37,85.06 90.14,86.3 v2(89.5,86.3)
  BOTTOM w0.114: DM2.70 123.78,46.95 123.83,47.01 123.83,47.53 v2(123.54,47.82) ; v2(89.5,86.3) 89.49,86.31 89.49,86.31 CPU1.AR32
M_B_DQ26: length 65.7
  L5 w0.114: v2(91.7,87.9) 92.18,87.42 92.18,87.05 92.51,86.72 92.83,86.72 93.35,86.2 93.74,86.2 95.25,84.68 98.22,84.68 98.79,84.11 99.04,84.11 103.2,79.96 103.2,75.55 108.68,70.07 108.68,68.4 126.71,50.37 129.18,50.37 129.44,50.12 129.44,49.17 129.32,49.05 128.84,49.05 128.72,48.92 128.72,48.71 128.83,48.59 129.32,48.59 129.44,48.48 129.44,48.19 129.31,48.06 v2(128.02,48.06)
  BOTTOM w0.114: CPU1.AV30 v2(91.7,87.9) ; DM2.83 127.03,51.1 127.03,49.05 v2(128.02,48.06)
M_B_DQ27: length 66.5
  L5 w0.114: v2(128.02,47.42) 128.02,46.92 127.81,46.71 126.41,46.71 126.29,46.84 126.29,47.37 125.82,47.84 125.82,49.81 107.65,67.98 107.65,69.64 101.7,75.6 101.7,79.97 99.07,82.6 99.07,82.69 97.72,84.04 94.99,84.04 93.47,85.55 93.08,85.55 92.69,85.94 91.76,85.94 91.28,86.42 91.28,88.13 v2(91.7,88.54)
  BOTTOM w0.114: v2(128.02,47.42) 128.02,45.6 127.26,44.84 127.26,42.92 DM2.84 ; CPU1.AV29 v2(91.7,88.54)
M_B_DQ28: length 64.4
  L5 w0.076: 89.11,86.11 89.11,86.46 89.53,86.89 89.53,88.19 v2(89.88,88.54)
  L5 w0.114: 89.11,86.11 89.11,85.75 90.01,84.85 91.35,84.85 91.96,84.24 93.24,84.24 94.61,82.87 95.92,82.87 99.22,79.56 99.22,78.34 99.46,78.1 99.46,73.49 101.41,71.54 102.34,71.54 105.6,68.27 105.6,67.6 122.86,50.34 122.86,49.91 122.98,49.8 123.32,49.8 123.45,49.67 123.45,49.46 123.33,49.34 122.98,49.34 122.86,49.23 122.86,48.33 122.91,48.29 122.91,47.8 v2(122.91,47.8)
  BOTTOM w0.114: CPU1.AR30 89.8,88.54 v2(89.88,88.54) ; DM2.66 122.78,43.88 122.96,44.06 122.96,47.75 v2(122.91,47.8)
M_B_DQ29: length 64.3
  L5 w0.076: v2(89,88.51) 89.33,88.18 89.33,87.01 88.87,86.55 88.87,86.06
  L5 w0.114: 88.87,86.06 88.87,85.68 89.92,84.63 91.26,84.63 91.9,84 93.17,84 94.52,82.65 95.83,82.65 98.21,80.27 98.21,79.39 99,78.6 99,78.25 99.12,78.13 99.12,73.34 101.27,71.19 101.4,71.19 101.8,70.8 101.96,70.8 102.2,71.03 102.36,71.03 102.52,70.87 102.52,70.71 102.28,70.47 102.28,70.31 102.45,70.15 102.61,70.15 102.84,70.38 103,70.38 103.17,70.22 103.17,70.06 102.93,69.83 102.93,69.66 103.09,69.5 103.25,69.5 103.49,69.74 103.65,69.74 103.81,69.57 103.81,69.41 103.58,69.18 103.58,69.02 103.74,68.86 103.9,68.86 104.14,69.09 104.3,69.09 104.46,68.93 104.46,68.77 104.27,68.58 104.27,68.42 122.52,50.18 122.52,48.45 122.39,48.32 v2(122.08,48.32)
  BOTTOM w0.114: CPU1.AR29 89.12,88.51 v2(89,88.51) ; v2(122.08,48.32) 122.08,48.34 123.03,49.29 DM2.67
M_B_DQ30: length 64.4
  L5 w0.114: v2(91.7,86.59) 92,86.29 92.66,86.29 93.17,85.77 93.56,85.77 95.08,84.25 97.81,84.25 101.37,80.69 101.46,80.69 102.51,79.64 102.51,79.12 102.4,79 102.2,79 102.09,78.89 102.09,78.66 102.2,78.55 102.4,78.55 102.51,78.43 102.51,78.2 102.4,78.09 102.2,78.09 102.09,77.97 102.09,77.75 102.2,77.63 102.4,77.63 102.51,77.52 102.51,77.29 102.4,77.17 102.2,77.17 102.09,77.06 102.09,76.83 102.2,76.72 102.4,76.72 102.51,76.6 102.51,76.37 102.4,76.26 102.2,76.26 102.09,76.15 102.09,75.92 102.2,75.8 102.4,75.8 102.51,75.69 102.51,75.27 107.99,69.79 107.99,68.12 126.17,49.95 126.17,49.6 126.28,49.49 126.63,49.49 126.74,49.38 126.74,49.15 126.63,49.03 126.28,49.03 126.17,48.92 126.17,47.98 126.72,47.42 v2(126.72,47.42)
  BOTTOM w0.114: v2(91.7,86.59) 91.69,86.6 CPU1.AV32 ; v2(126.72,47.42) 126.62,47.32 126.62,46.33 126.28,45.98 DM2.80
M_B_DQ31: length 64
  L5 w0.114: v2(126.7,48.06) 127.08,48.44 127.08,49.4 127.21,49.53 128.84,49.53 128.98,49.67 128.98,49.9 128.85,50.03 126.57,50.03 108.34,68.26 108.34,69.93 102.85,75.41 102.85,79.81 98.77,83.9 98.7,83.9 98.13,84.47 95.17,84.47 93.65,85.98 93.26,85.98 92.75,86.5 92.42,86.5 91.7,87.23 v2(91.7,87.25)
  BOTTOM w0.114: v2(91.7,87.25) 91.66,87.28 91.66,87.28 CPU1.AV31 ; DM2.79 126.03,48.53 126.5,48.06 v2(126.7,48.06)
M_B_DQ32: length 88.2
  L3 w0.089: v2(94.74,77.03) 96.05,75.72 96.05,74.38 96.14,74.29 96.91,74.29 97,74.2 97,74.02 96.91,73.93 96.14,73.93 96.05,73.84 96.05,73.66 96.14,73.57 96.91,73.57 97,73.49 97,71.92 99.89,69.03 101.85,69.03 109.3,61.57 141.33,61.57 151.66,51.24 151.66,49.09 151.56,48.98 151.56,48.21 v2(150.95,47.6)
  BOTTOM w0.076: 93.49,83 93.44,83.06 93.44,83.76 93.42,83.8 93.41,83.81 93.41,83.82 93.33,84.06 93.33,84.3 93.36,84.39 93.36,84.62 93.28,84.84 93.28,84.85 93.2,85.06 CPU1.BA35
  BOTTOM w0.114: DM2.173 151.53,48.18 v2(150.95,47.6) ; 93.49,83 93.49,77.6 94.01,77.09 94.68,77.09 v2(94.74,77.03)
M_B_DQ33: length 89
  L3 w0.089: v2(150.75,44.94) 150.15,45.55 150.15,51.63 141,60.77 108.45,60.77 101.13,68.09 98.2,68.09 98.01,68.28 98.01,68.4 98.09,68.48 98.09,68.61 97.97,68.73 97.84,68.73 97.76,68.65 97.64,68.65 97.51,68.78 97.51,68.91 97.59,68.98 97.59,69.11 97.46,69.24 97.34,69.24 97.26,69.16 97.13,69.16 95.17,71.12 95.17,72.79 v2(94.75,73.22)
  BOTTOM w0.076: CPU1.BA34 92.79,85.16 92.79,84.72 92.75,84.69 92.75,84.15 92.7,84.04 92.69,84.03 92.69,83.51 92.88,83.31 92.88,80.92 92.83,80.88
  BOTTOM w0.114: v2(150.75,44.94) 150.78,44.92 DM2.170 ; v2(94.75,73.22) 94.71,73.25 94.07,73.25 92.83,74.49 92.83,80.88
M_B_DQ34: length 87.8
  L3 w0.089: v2(96.09,79.81) 97.19,79.81 97.51,79.49 97.51,79.31 97.3,79.1 97.3,78.98 97.43,78.85 97.55,78.85 97.71,79.01 97.84,79.01 97.96,78.88 97.96,78.76 97.81,78.6 97.81,78.47 97.93,78.35 98.06,78.35 98.21,78.5 98.34,78.5 98.47,78.38 98.47,78.25 98.31,78.1 98.31,77.97 98.44,77.85 98.56,77.85 98.72,78 98.84,78 98.97,77.88 98.97,77.75 98.81,77.59 98.81,77.47 98.94,77.34 99.06,77.34 99.22,77.5 99.35,77.5 99.53,77.31 99.53,76.75 99.7,76.59 100.07,76.59 100.16,76.5 100.16,76.32 100.07,76.23 99.72,76.23 99.63,76.14 99.63,75.97 99.72,75.88 100.07,75.88 100.16,75.79 100.16,75.61 100.07,75.52 99.72,75.52 99.63,75.43 99.63,75.26 99.72,75.17 100.07,75.17 100.16,75.08 100.16,74.9 100.07,74.81 99.72,74.81 99.63,74.72 99.63,74.54 99.72,74.46 100.07,74.46 100.16,74.37 100.16,74.19 100.07,74.1 99.72,74.1 99.63,74.01 99.63,73.74 110.07,63.3 142.05,63.3 154.57,50.78 154.57,49.79 154.7,49.67 v2(155,49.67)
  BOTTOM w0.076: CPU1.BC35 94.73,84.84 94.73,84.21 94.73,84.19 94.84,84 94.84,83.5 95.01,83.32 95.01,82.86
  BOTTOM w0.114: v2(96.09,79.81) 95.53,79.81 95.01,80.32 95.01,82.86 ; v2(155,49.67) 155,49.84 155.03,49.86 DM2.187
M_B_DQ35: length 89.2
  L3 w0.089: v2(94.77,77.66) 94.87,77.56 96.69,77.56 97.91,76.34 97.91,74.31 109.72,62.5 141.72,62.5 153.68,50.54 153.68,47.42 v2(153.28,47.02)
  BOTTOM w0.076: CPU1.BC34 93.69,85.81 93.48,85.6 93.48,84.78 93.53,84.65 93.53,84.36 93.5,84.3 93.5,84.06 93.58,83.85 93.58,83.84 93.6,83.79 93.6,83.44 93.7,83.35 93.7,82.94
  BOTTOM w0.114: v2(94.77,77.66) 94.76,77.67 94.19,77.67 93.7,78.16 93.7,82.94 ; DM2.183 154.03,49.84 153.84,49.65 153.84,49.65 153.82,49.64 153.82,47.56 v2(153.28,47.02)
M_B_DQ36: length 86.8
  L3 w0.089: v2(94.72,75.76) 94.74,75.76 95.7,74.8 95.7,71.77 96.15,71.33 96.28,71.33 96.55,71.6 96.67,71.6 96.8,71.47 96.8,71.35 96.53,71.07 96.53,70.95 96.65,70.82 96.78,70.82 97.05,71.09 97.18,71.09 97.3,70.97 97.3,70.84 97.03,70.57 97.03,70.45 97.16,70.32 97.28,70.32 97.55,70.59 97.68,70.59 97.81,70.47 97.81,70.34 97.53,70.07 97.53,69.94 97.66,69.82 97.79,69.82 98.06,70.09 98.18,70.09 98.31,69.96 98.31,69.84 98.04,69.57 98.04,69.44 98.16,69.31 98.29,69.31 98.56,69.59 98.69,69.59 98.81,69.46 98.81,69.33 98.54,69.06 98.54,68.94 98.74,68.74 101.76,68.74 109.19,61.31 141.22,61.31 151.4,51.13 151.4,49.3 v2(151,48.9)
  BOTTOM w0.076: CPU1.BA37 93.27,83.69 93.27,82.93 93.29,82.92
  BOTTOM w0.114: 93.29,82.92 93.29,77.19 v2(94.72,75.76) ; v2(151,48.9) 150.53,49.38 DM2.169
M_B_DQ37: length 87.8
  L3 w0.089: v2(94.72,74.49) 94.98,74.49 95.17,74.29 95.17,73.17 95.44,72.9 95.44,71.64 95.91,71.17 95.91,71.04 95.83,70.97 95.83,70.84 95.96,70.72 96.09,70.72 96.16,70.79 96.28,70.79 96.41,70.66 96.41,70.54 96.34,70.47 96.34,70.34 96.46,70.21 96.59,70.21 96.66,70.29 96.79,70.29 96.91,70.16 96.91,70.04 96.84,69.96 96.84,69.84 96.97,69.71 97.09,69.71 97.16,69.78 97.29,69.78 98.72,68.36 101.24,68.36 108.56,61.04 141.11,61.04 150.41,51.74 150.41,46.8 v2(150.88,46.34)
  BOTTOM w0.076: 93.09,83 93.09,83.36 92.85,83.6 92.85,83.98 92.94,84.14 92.94,84.19 CPU1.BA36
  BOTTOM w0.114: v2(150.88,46.34) 151.78,45.44 DM2.174 ; 93.09,83 93.09,76.12 v2(94.72,74.49)
M_B_DQ38: length 87.1
  L3 w0.089: v2(154.31,44.98) 154.31,50.67 141.94,63.03 109.94,63.03 99.04,73.94 99.04,74.33 99.13,74.42 99.27,74.42 99.37,74.51 99.37,74.68 99.28,74.77 99.13,74.77 99.04,74.86 99.04,75.04 99.13,75.13 99.27,75.13 99.37,75.22 99.37,75.4 99.28,75.48 99.13,75.48 99.04,75.57 99.04,75.75 99.13,75.84 99.27,75.84 99.37,75.94 99.37,76.11 99.28,76.2 99.13,76.2 99.04,76.28 99.04,76.72 v2(96.49,79.27)
  BOTTOM w0.076: 94.8,83.01 94.8,83.31 94.67,83.43 94.67,83.96 94.59,84.11 94.56,84.17 94.41,84.45 94.41,84.5 CPU1.BC36
  BOTTOM w0.114: DM2.186 154.78,44.52 v2(154.31,44.98) ; 94.8,83.01 94.8,80.29 94.81,80.28 94.81,80.24 95.44,79.6 95.48,79.6 95.81,79.27 v2(96.49,79.27)
M_B_DQ39: length 86.3
  L3 w0.089: v2(153.26,45.03) 153.95,45.73 153.95,50.65 141.83,62.77 109.83,62.77 98.3,74.3 98.3,74.64 98.39,74.73 98.62,74.73 98.72,74.83 98.72,75 98.63,75.09 98.39,75.09 98.3,75.17 98.3,75.35 98.39,75.44 98.62,75.44 98.72,75.54 98.72,75.71 98.63,75.8 98.39,75.8 98.3,75.89 98.3,76.5 96.79,78 v2(96.52,78)
  BOTTOM w0.076: CPU1.BC37 94.51,83.75 94.51,83.36 94.59,83.28 94.59,83.01
  BOTTOM w0.114: 94.59,83.01 94.59,79.94 v2(96.52,78) ; DM2.182 153.78,44.52 v2(153.26,45.03)
M_B_DQ40: length 90
  L3 w0.089: v2(156.54,49.03) 156.95,49.44 156.95,50.07 142.57,64.45 110.67,64.45 108.16,66.96 108.16,67.08 108.42,67.35 108.42,67.48 108.3,67.6 108.16,67.6 107.9,67.34 107.77,67.34 107.64,67.48 107.64,67.6 108.19,68.16 108.19,68.29 108.06,68.42 107.93,68.42 107.38,67.86 107.25,67.86 107.12,68 107.12,68.12 107.67,68.68 107.67,68.81 107.54,68.94 107.41,68.94 106.86,68.38 106.73,68.38 106.59,68.52 106.59,68.64 107.15,69.2 107.15,69.33 107.02,69.46 106.89,69.46 106.33,68.91 106.21,68.91 106.07,69.04 106.07,69.17 106.63,69.72 106.63,69.85 101.55,74.93 101.55,77.08 100.98,77.65 v2(100.66,77.65)
  BOTTOM w0.076: CPU1.BE35 95.72,85.06 95.81,84.8 95.88,84.62 95.88,84.39 95.86,84.33 95.86,84.03 95.91,83.89 95.91,83.67 95.93,83.61 95.93,83.56 96.02,83.35 96.02,83.12
  BOTTOM w0.114: DM2.195 157.03,49.51 v2(156.54,49.03) ; 96.02,83.12 96.02,81.81 96.02,81.81 96.02,81.75 97.82,79.95 97.82,79.4 99.57,77.65 v2(100.66,77.65)
M_B_DQ41: length 90
  L3 w0.089: v2(100.69,73.85) 100.92,73.62 100.92,73.6 101.6,72.92 101.6,72.79 101.46,72.65 101.46,72.52 102.11,71.87 102.24,71.87 102.8,72.43 102.92,72.43 103.06,72.29 103.06,72.16 102.5,71.61 102.5,71.48 102.63,71.35 102.76,71.35 103.32,71.9 103.44,71.9 103.58,71.77 103.58,71.64 103.02,71.09 103.02,70.96 103.16,70.83 103.28,70.83 103.84,71.38 103.96,71.38 104.1,71.25 104.1,71.12 103.54,70.57 103.54,70.44 110.34,63.64 142.25,63.64 155.49,50.4 155.49,48.74 v2(155.06,48.31)
  BOTTOM w0.076: CPU1.BE34 95.62,85.58 95.33,85.29 95.33,84.26 95.2,84.03 95.2,83.63 95.41,83.42 95.41,83.11
  BOTTOM w0.114: DM2.191 156.03,49.28 v2(155.06,48.31) ; 95.41,83.11 95.41,83.1 95.41,81.1 96.93,79.57 96.93,78.18 97.41,77.7 97.41,77.13 v2(100.69,73.85)
M_B_DQ42: length 90.2
  L3 w0.089: v2(159.51,47.73) 159.95,48.17 159.95,49.82 159.43,50.33 159.13,50.33 143.29,66.17 127.88,66.17 127.17,66.88 123.8,66.88 123.41,66.49 113.22,66.49 106.17,73.54 106.05,73.54 105.81,73.3 105.68,73.3 105.56,73.43 105.56,73.56 105.79,73.79 105.79,73.92 105.67,74.04 105.54,74.04 105.3,73.81 105.18,73.81 105.05,73.93 105.05,74.06 105.29,74.3 105.29,74.42 105.16,74.55 105.04,74.55 104.8,74.31 104.68,74.31 104.55,74.44 104.55,74.56 104.79,74.8 104.79,74.92 104.66,75.05 104.54,75.05 104.3,74.81 104.17,74.81 104.05,74.94 104.05,75.06 104.29,75.3 104.29,75.43 104.16,75.55 104.03,75.55 103.8,75.32 103.67,75.32 103.54,75.44 103.54,75.57 103.78,75.8 103.78,75.93 103.3,76.41 103.3,78.23 100,81.54 v2(98.78,81.54)
  BOTTOM w0.076: 97.58,83.8 97.34,84.05 97.24,84.22 97.24,84.84 97.16,84.92 CPU1.BG35
  BOTTOM w0.114: 97.58,83.8 97.58,83.04 97.59,83.04 97.59,82.42 98.48,81.54 v2(98.78,81.54) ; v2(159.51,47.73) 160.03,48.25 DM2.207
M_B_DQ43: length 90.8
  L3 w0.089: v2(157.26,45.03) 156.79,45.5 156.79,47.9 157.22,48.33 157.22,50.18 142.69,64.71 110.78,64.71 109.7,65.79 109.7,67.16 109.53,67.33 109.4,67.33 108.85,66.77 108.72,66.77 108.59,66.91 108.59,67.03 109.14,67.59 109.14,67.71 101.82,75.04 101.82,77.14 v2(100.66,78.29)
  BOTTOM w0.076: CPU1.BG34 96.2,85.81 95.99,85.6 95.99,84.9 96.02,84.87 96.02,84.73 96.04,84.67 96.04,84.35 96.04,84.35 96.02,84.3 96.02,84.06 96.07,83.92 96.07,83.7 96.1,83.64 96.1,83.59 96.22,83.29 96.22,83.08
  BOTTOM w0.114: v2(157.26,45.03) 156.78,44.54 DM2.194 ; v2(100.66,78.29) 100.65,78.28 99.32,78.28 98.1,79.5 98.1,79.96 96.22,81.83 96.22,81.94 96.22,81.94 96.22,83.08
M_B_DQ44: length 88.9
  L3 w0.089: v2(100.64,76.38) 101.24,75.78 101.24,74.86 105.63,70.48 105.63,69.11 110.56,64.18 142.46,64.18 156.09,50.56 156.09,44.92 157.1,43.91 157.65,43.91 v2(158.75,45.01)
  BOTTOM w0.076: CPU1.BE37 95.74,83.74 95.74,83.59 95.81,83.41 95.81,83.12
  BOTTOM w0.114: v2(158.75,45.01) 159.28,44.49 DM2.204 ; 95.81,83.12 95.81,81.66 97.46,80.01 97.46,78.94 100,76.4 100.61,76.4 v2(100.64,76.38)
M_B_DQ45: length 89.3
  L3 w0.089: v2(100.59,75.11) 100.61,75.11 104.54,71.18 104.54,71.06 103.98,70.5 103.98,70.38 104.12,70.24 104.24,70.24 104.8,70.8 104.93,70.8 105.06,70.66 105.06,70.54 104.5,69.98 104.5,69.85 104.69,69.67 104.82,69.67 105.09,69.94 105.22,69.94 105.35,69.81 105.35,69.68 105.08,69.4 105.08,69.28 110.44,63.91 142.35,63.91 155.75,50.51 155.75,46.94 v2(155.28,46.47)
  BOTTOM w0.076: CPU1.BE36 95.62,84.45 95.39,84.03 95.37,83.99 95.37,83.71 95.61,83.47 95.61,83
  BOTTOM w0.114: DM2.190 155.78,45.98 v2(155.28,46.47) ; v2(100.59,75.11) 100.59,75.15 100.5,75.24 99.89,75.24 97.81,77.32 97.81,77.59 97.13,78.27 97.13,80.05 95.61,81.58 95.61,83
M_B_DQ46: length 89
  L3 w0.089: v2(99.17,81.03) 100.12,81.03 103.03,78.13 103.03,75.58 108.3,70.31 108.43,70.31 108.6,70.48 108.72,70.48 108.85,70.35 108.85,70.23 108.68,70.06 108.68,69.93 108.8,69.81 108.93,69.81 109.17,70.04 109.29,70.04 109.42,69.92 109.42,69.79 109.18,69.55 109.18,69.43 109.31,69.3 109.43,69.3 109.67,69.54 109.79,69.54 109.92,69.41 109.92,69.29 109.68,69.05 109.68,68.93 109.81,68.8 109.93,68.8 110.17,69.04 110.3,69.04 110.42,68.91 110.42,68.79 110.19,68.55 110.19,68.42 110.31,68.3 110.44,68.3 110.67,68.53 110.8,68.53 110.93,68.41 110.93,68.28 110.69,68.05 110.69,67.92 110.81,67.79 110.94,67.79 111.18,68.03 111.3,68.03 111.43,67.91 111.43,67.78 111.19,67.54 111.19,67.42 111.32,67.29 111.44,67.29 111.68,67.53 111.81,67.53 111.93,67.4 111.93,67.28 111.69,67.04 111.69,66.91 111.82,66.79 111.95,66.79 112.18,67.03 112.31,67.03 112.43,66.9 112.43,66.77 112.2,66.54 112.2,66.41 112.39,66.22 123.52,66.22 123.91,66.61 127.06,66.61 127.77,65.91 143.18,65.91 158.83,50.26 158.83,50.04 158.83,49.69 v2(159.52,49)
  BOTTOM w0.076: CPU1.BG36 96.92,84.45 97.08,84.17 97.08,84.17 97.29,83.78 97.34,83.73 97.34,83.69 97.38,83.61
  BOTTOM w0.114: v2(99.17,81.03) 98.69,81.03 97.39,82.34 97.39,82.95 97.38,82.96 97.38,83.61 ; v2(159.52,49) 159.03,49.49 DM2.203
M_B_DQ47: length 88.2
  L3 w0.089: v2(99.64,80.56) 100.32,80.56 101.63,79.26 101.63,78.8 102.76,77.67 102.76,75.47 112.59,65.64 120.46,65.64 120.55,65.73 120.55,65.87 120.64,65.95 120.81,65.95 120.9,65.87 120.9,65.73 120.99,65.64 121.17,65.64 121.26,65.73 121.26,65.87 121.35,65.95 121.53,65.95 121.61,65.87 121.61,65.73 121.7,65.64 121.88,65.64 121.97,65.73 121.97,65.87 122.06,65.95 122.24,65.95 122.33,65.87 122.33,65.73 122.41,65.64 122.59,65.64 122.68,65.73 122.68,65.87 122.77,65.95 122.95,65.95 123.04,65.87 123.04,65.73 123.13,65.64 123.39,65.64 124.08,66.33 126.96,66.33 127.65,65.64 143.07,65.64 158.56,50.15 158.56,49.58 158.86,49.28 158.86,46.33 v2(158.8,46.28)
  BOTTOM w0.114: v2(158.8,46.28) 160.31,44.77 160.31,44.15 160.33,44.14 160.33,42.95 DM2.208 ; v2(99.64,80.56) 98.88,80.56 97.13,82.31 97.13,83.65 CPU1.BG37
M_B_DQ48: length 91.4
  L3 w0.089: v2(160.74,49.03) 161.13,49.43 161.13,49.84 160.11,50.87 159.58,50.87 143.66,66.78 128.34,66.78 127.55,67.57 117.92,67.57 116.67,68.82 112.24,68.82 105.26,75.81 105.26,75.93 105.75,76.42 105.75,76.55 105.63,76.67 105.49,76.67 105.01,76.18 104.88,76.18 104.69,76.37 104.69,76.5 105.18,76.99 105.18,77.11 105.05,77.24 104.93,77.24 104.44,76.75 104.31,76.75 104.19,76.88 104.19,77 104.68,77.49 104.68,77.62 98.7,83.59 95.57,83.59 93.52,85.64 v2(93.52,86.61)
  BOTTOM w0.114: DM2.211 161.03,49.97 161.12,49.87 161.15,49.85 161.15,49.44 v2(160.74,49.03) ; CPU1.BA32 93.52,86.61 v2(93.52,86.61)
M_B_DQ49: length 92.1
  L3 w0.089: v2(93.52,87.27) 93.52,87.18 93.92,86.78 93.92,85.61 95.68,83.85 98.94,83.85 106.08,76.71 106.08,76.17 105.86,75.95 105.86,75.58 112.35,69.09 116.78,69.09 118.03,67.84 127.66,67.84 128.45,67.05 143.77,67.05 159.69,51.13 160.54,51.13 161.4,50.27 161.4,48.48 v2(160.68,47.76)
  BOTTOM w0.114: CPU1.BA31 v2(93.52,87.27) ; DM2.215 162.03,49.09 160.69,47.76 v2(160.68,47.76)
M_B_DQ50: length 93.9
  L3 w0.089: v2(95.36,87.88) 95.7,87.53 95.7,86.8 96.07,86.43 96.07,86.16 97.38,84.84 100.14,84.84 101.35,83.64 103.04,83.64 104.43,82.25 104.43,82.12 104.03,81.73 104.03,81.6 104.19,81.45 104.31,81.45 104.71,81.84 104.83,81.84 104.99,81.69 104.99,81.56 104.59,81.17 104.59,81.04 104.74,80.89 104.87,80.89 105.27,81.29 105.39,81.29 105.54,81.13 105.54,81.01 105.15,80.61 105.15,80.49 105.3,80.33 105.43,80.33 105.82,80.73 105.95,80.73 106.1,80.57 106.1,80.45 105.71,80.05 105.71,79.93 105.86,79.78 105.98,79.78 106.38,80.17 106.51,80.17 106.66,80.02 106.66,79.89 106.26,79.5 106.26,79.37 114.34,71.29 117.76,71.29 119.75,69.3 128.27,69.3 129.06,68.51 144.37,68.51 160.22,52.66 161.62,52.66 164.05,50.23 164.05,49.79 164.18,49.67 v2(164.47,49.67)
  BOTTOM w0.114: CPU1.BD31 95.26,87.88 v2(95.36,87.88) ; DM2.225 164.53,49.77 164.47,49.71 v2(164.47,49.67)
M_B_DQ51: length 93.5
  L3 w0.089: v2(95.3,87.18) 95.3,86.93 95.83,86.4 95.83,86.12 97.3,84.65 100.06,84.65 101.34,83.37 102.93,83.37 103.61,82.68 103.61,81.64 114.23,71.03 117.65,71.03 119.64,69.03 128.16,69.03 128.94,68.24 144.26,68.24 160.11,52.39 161.51,52.39 163.78,50.12 163.78,48.41 v2(162.79,46.3)
  BOTTOM w0.114: v2(95.3,87.18) 95.21,87.18 CPU1.BD32 ; DM2.224 164.28,45.08 163.05,46.3 v2(162.79,46.3)
M_B_DQ52: length 93.3
  L3 w0.089: v2(93.52,87.9) 93.12,87.5 93.12,85.47 95.43,83.16 98.04,81.94 99.97,81.94 103.8,78.12 103.8,76.89 112.13,68.56 112.35,68.56 116.56,68.56 117.81,67.3 127.44,67.3 128.23,66.52 143.55,66.52 159.47,50.6 159.71,50.6 160.23,50.08 160.23,47.7 v2(160.8,46.28)
  BOTTOM w0.114: v2(160.8,46.28) 160.91,46.28 162.28,44.91 DM2.216 ; CPU1.BA30 v2(93.52,87.9)
M_B_DQ53: length 94
  L3 w0.089: v2(93.52,88.54) 93.92,88.14 93.92,87.05 94.11,86.86 94.11,85.86 95.17,84.81 96.95,84.04 99.13,84.04 106.52,76.65 112.25,70.26 113.16,69.36 116.89,69.36 118.14,68.11 127.77,68.11 128.56,67.32 143.88,67.32 159.8,51.4 160.91,51.4 161.67,50.64 161.67,45.9 v2(160.78,45.01)
  BOTTOM w0.114: DM2.212 161.28,44.51 v2(160.78,45.01) ; CPU1.BA29 v2(93.52,88.54)
M_B_DQ54: length 95.1
  L3 w0.089: v2(164.84,45.02) 164.84,46.59 165.41,47.15 165.41,50.37 162.58,53.19 160.44,53.19 144.59,69.04 129.28,69.04 128.49,69.83 119.97,69.83 117.98,71.83 115.6,71.83 103.26,84.17 101.35,84.17 100.2,85.32 98.7,85.32 97.28,86.74 97.02,86.74 96.79,86.97 96.79,87.37 95.85,88.3 95.85,88.66 v2(95.36,89.15)
  BOTTOM w0.089: CPU1.BD29 95.24,89.15 v2(95.36,89.15)
  BOTTOM w0.114: DM2.228 165.28,44.49 164.84,44.93 v2(164.84,45.02)
M_B_DQ55: length 94.6
  L3 w0.089: v2(164.52,48.36) 164.92,48.76 164.92,50.31 162.31,52.93 160.33,52.93 144.48,68.78 129.17,68.78 128.38,69.57 119.86,69.57 117.87,71.56 115.49,71.56 108.98,78.07 108.86,78.07 108.46,77.68 108.34,77.68 108.18,77.83 108.18,77.95 108.58,78.35 108.58,78.47 108.43,78.63 108.3,78.63 107.91,78.23 107.78,78.23 107.63,78.39 107.63,78.51 108.02,78.91 108.02,79.03 103.15,83.9 101.35,83.9 100.13,85.13 97.37,85.13 96.42,86.07 96.42,86.45 95.89,86.98 95.89,87.98 v2(95.36,88.52)
  BOTTOM w0.089: CPU1.BD30 95.26,88.53 95.35,88.53 v2(95.36,88.52)
  BOTTOM w0.114: v2(164.52,48.36) 165.53,49.37 DM2.229
M_B_DQ56: length 99.6
  L5 w0.114: v2(97.19,87.8) 97.6,87.39 97.6,86.91 97.67,86.84 97.67,86.33 97.91,86.09 98.04,86.09 99.15,84.98 99.78,84.98 100.88,83.88 102.84,83.88 104.57,82.15 104.57,76.24 110.14,70.67 110.14,69.03 127.28,51.89 161.32,51.89 161.43,52 161.43,52.71 161.55,52.83 161.77,52.83 161.89,52.71 161.89,52 162,51.89 162.23,51.89 162.35,52 162.35,52.72 162.46,52.84 162.69,52.84 162.8,52.72 162.8,52 162.92,51.89 163.15,51.89 163.26,52 163.26,52.72 163.38,52.84 163.6,52.84 163.72,52.72 163.72,52 163.83,51.89 164.06,51.89 164.18,52 164.18,52.72 164.29,52.84 164.52,52.84 164.63,52.72 164.63,52 164.75,51.89 165.81,51.89 166.53,51.18 v2(166.53,49.67)
  BOTTOM w0.114: CPU1.BG31 96.98,87.77 97.12,87.77 97.16,87.8 v2(97.19,87.8) ; DM2.233 v2(166.53,49.67)
M_B_DQ57: length 99.2
  L5 w0.114: v2(97.19,87.14) 97.19,86.82 97.45,86.55 97.45,86.24 98.36,85.33 98.49,85.33 99.06,84.76 99.69,84.76 100.92,83.53 102.7,83.53 104.23,82.01 104.23,76.1 109.79,70.53 109.79,68.89 127.13,51.55 160.06,51.55 160.18,51.43 160.18,51.2 160.29,51.09 160.52,51.09 160.64,51.2 160.64,51.43 160.75,51.55 160.98,51.55 161.09,51.43 161.09,51.2 161.21,51.09 161.44,51.09 161.55,51.2 161.55,51.43 161.66,51.55 161.89,51.55 162.01,51.43 162.01,51.2 162.12,51.09 162.35,51.09 162.46,51.2 162.46,51.43 162.58,51.55 162.81,51.55 162.92,51.43 162.92,51.2 163.04,51.09 163.26,51.09 163.38,51.2 163.38,51.43 163.49,51.55 163.72,51.55 163.84,51.43 163.84,51.2 163.95,51.09 164.18,51.09 164.29,51.2 164.29,51.43 164.41,51.55 164.64,51.55 164.75,51.43 164.75,51.2 164.86,51.09 165.09,51.09 165.21,51.2 165.21,51.43 165.32,51.55 165.66,51.55 165.95,51.26 165.95,48.96 v2(166.52,48.39)
  BOTTOM w0.089: CPU1.BG32 96.98,87.12 97.1,87.12 97.11,87.14 v2(97.19,87.14)
  BOTTOM w0.114: v2(166.52,48.39) 166.54,48.39 167.53,49.38 DM2.237
M_B_DQ58: length 99.2
  L5 w0.114: v2(169.24,44.97) 168.64,45.57 168.64,46.15 167.65,47.13 167.65,51.51 164.89,54.27 150.12,54.27 150,54.15 150,53.98 149.89,53.87 149.7,53.87 149.58,53.98 149.58,54.15 149.47,54.27 148.21,54.27 147.92,54.57 126.05,54.57 111.17,69.45 111.17,71.1 105.6,76.67 105.6,82.59 103.32,84.88 101.03,84.88 100.27,85.64 99.42,85.64 98.94,86.12 v2(98.94,87.18)
  BOTTOM w0.114: v2(98.94,87.18) 98.94,87.15 CPU1.BK32 ; DM2.246 169.78,44.58 169.39,44.97 v2(169.24,44.97)
M_B_DQ59: length 99.8
  L5 w0.114: v2(98.99,87.86) 99.35,87.49 99.35,87.01 99.18,86.83 99.18,86.19 99.51,85.85 100.6,85.85 101.36,85.09 103.65,85.09 105.94,82.8 105.94,76.81 111.51,71.24 111.51,69.6 126.2,54.91 160.14,54.91 160.25,54.8 160.25,54.73 160.36,54.61 160.59,54.61 160.71,54.73 160.71,54.8 160.82,54.91 161.05,54.91 161.16,54.8 161.16,54.73 161.28,54.61 161.51,54.61 161.62,54.73 161.62,54.8 161.74,54.91 161.96,54.91 162.08,54.8 162.08,54.73 162.19,54.61 162.42,54.61 162.54,54.73 162.54,54.8 162.65,54.91 162.88,54.91 162.99,54.8 162.99,54.73 163.11,54.61 163.34,54.61 163.45,54.73 163.45,54.8 163.56,54.91 163.79,54.91 163.91,54.8 163.91,54.73 164.02,54.61 164.25,54.61 164.36,54.73 164.36,54.8 164.48,54.91 164.82,54.91 168.03,51.71 168.03,50.7 168.14,50.59 168.59,50.59 168.7,50.48 168.7,50.25 168.59,50.13 168.14,50.13 168.03,50.02 168.03,48.69 v2(168.51,48.21)
  BOTTOM w0.114: v2(98.99,87.86) 98.63,87.5 CPU1.BK31 ; v2(168.51,48.21) 169.53,49.23 DM2.245
M_B_DQ60: length 100.2
  L5 w0.114: v2(165.79,44.97) 163.82,46.94 162.21,46.94 161.67,47.47 161.67,49.32 160.59,50.4 157.06,50.4 156.95,50.52 156.95,50.75 156.83,50.86 156.6,50.86 156.49,50.75 156.49,50.52 156.37,50.4 156.15,50.4 156.03,50.52 156.03,50.75 155.92,50.86 155.69,50.86 155.57,50.75 155.57,50.52 155.46,50.4 155.23,50.4 155.12,50.52 155.12,50.75 155,50.86 154.77,50.86 154.66,50.75 154.66,50.52 154.55,50.4 151.82,50.4 151.36,50.86 126.85,50.86 109.11,68.6 109.11,70.25 103.54,75.82 103.54,80.93 101.63,82.84 101.01,82.84 99.51,84.33 98.88,84.33 98.31,84.9 97.27,84.9 95.88,86.29 95.88,87.4 96.68,88.19 96.68,88.7 v2(97.13,89.16)
  BOTTOM w0.089: v2(97.13,89.16) 96.77,88.8 CPU1.BG29
  BOTTOM w0.114: DM2.232 166.28,44.49 v2(165.79,44.97)
M_B_DQ61: length 100.1
  L5 w0.114: v2(165.84,46.31) 165.61,46.53 165.61,49.58 164.45,50.74 159.7,50.74 159.58,50.86 159.58,51.09 159.47,51.2 159.24,51.2 159.13,51.09 159.13,50.86 159.01,50.74 158.78,50.74 158.67,50.86 158.67,51.09 158.55,51.2 158.33,51.2 158.21,51.09 158.21,50.86 158.1,50.74 157.87,50.74 157.75,50.86 157.75,51.09 157.64,51.2 126.99,51.2 109.45,68.74 109.45,70.39 103.88,75.96 103.88,81.07 101.78,83.18 100.97,83.18 99.6,84.55 98.97,84.55 98.4,85.11 97.36,85.11 96.6,85.88 96.6,86.49 96.71,86.6 96.71,87.92 97.13,88.34 v2(97.13,88.43)
  BOTTOM w0.089: v2(97.13,88.43) 96.85,88.15 CPU1.BG30
  BOTTOM w0.114: DM2.236 167.28,44.87 v2(165.84,46.31)
M_B_DQ62: length 100.7
  L5 w0.114: v2(169.32,46.24) 169.03,46.24 168.76,46.51 168.76,47.18 168.95,47.37 168.95,47.73 169.04,47.82 169.04,51.17 164.96,55.25 126.34,55.25 111.85,69.74 111.85,71.48 106.42,76.92 106.42,82.86 103.72,85.56 103.22,85.56 102.82,85.96 102.17,85.96 102.08,85.87 100.89,85.87 100.25,86.51 100.25,87.35 100.25,87.35 99.69,87.91 99.62,87.91 v2(98.99,88.54)
  BOTTOM w0.114: v2(169.32,46.24) 169.51,46.24 170.78,44.98 DM2.250 ; CPU1.BK30 v2(98.99,88.54)
M_B_DQ63: length 101.9
  L5 w0.114: v2(98.98,89.17) 99.45,89.65 99.45,89.98 99.69,90.22 101.9,90.22 102.18,89.93 102.18,86.94 103.22,85.9 103.96,85.9 106.76,83.1 106.76,77.06 112.19,71.63 112.19,69.88 126.48,55.6 165.11,55.6 169.39,51.32 v2(169.39,47.54)
  BOTTOM w0.114: v2(98.98,89.17) 98.95,89.17 CPU1.BK29 ; v2(169.39,47.54) 169.52,47.54 170.53,48.55 DM2.249
M_B_DQS_DN0: length 56.6
  L5 w0.102: v2(88.05,80.52) 88.07,80.52 88.4,80.85 88.49,80.95 88.49,80.96 88.75,80.96 89.04,80.66 89.04,74.69 89.32,74.41 89.32,64.64 100.53,53.43 100.88,53.43 101.14,53.69 101.32,53.69 101.49,53.52 101.49,53.38 101.19,53.08 101.19,52.77 101.46,52.5 101.77,52.5 102.07,52.8 102.21,52.8 102.35,52.66 102.35,52.51 102.06,52.22 102.06,51.9 102.46,51.5 107.02,51.5 109.16,49.36 109.16,48.56 109,48.4 108.68,48.4 108.55,48.53 v2(108.55,48.71)
  BOTTOM w0.076: 88.68,82.9 88.66,82.9 88.66,82.99 88.64,83 88.64,83.21 88.5,83.35 88.5,83.66 88.5,83.99 88.47,84.08 88.47,84.28 88.5,84.36 88.5,84.36 88.5,84.63 88.49,84.67 88.47,84.73 88.47,84.93 88.5,85.01 88.56,85.07 88.65,85.07 88.72,84.99 CPU1.AP35
  BOTTOM w0.114: v2(108.55,48.71) 108.55,48.53 108.71,48.37 109.14,48.37 109.3,48.53 109.3,49.98 109.25,50.03 109.25,50.03 109.11,50.03 109.03,50.11 DM2.11 ; 88.68,82.9 88.68,81.15 v2(88.05,80.52)
M_B_DQS_DN1: length 57.7
  L5 w0.102: v2(113.97,47.02) 114.49,47.56 114.49,49.88 108.1,56.27 107.52,56.27 107.3,56.05 107.3,55.77 107.2,55.67 107,55.67 106.9,55.77 106.9,56.05 106.68,56.27 105.85,56.27 105.59,56.01 105.45,56.01 105.3,56.15 105.3,56.3 105.56,56.56 105.56,56.87 105.3,57.13 104.99,57.13 104.73,56.87 104.58,56.87 104.44,57.02 104.44,57.16 104.7,57.42 104.7,57.73 93.55,68.89 93.55,77.33 92.98,77.9 92.33,77.9 v2(92.15,78.07)
  BOTTOM w0.076: CPU1.AV34 91.24,85.39 91.38,85.26 91.43,85.23 91.6,85.15 91.72,84.83 91.63,84.57 91.63,84.43 91.68,84.29 91.68,84.07 91.6,83.84 91.6,83.79 91.57,83.77 91.57,82.53 91.62,82.47 91.62,81.87 91.65,81.84 91.65,81.82
  BOTTOM w0.114: 91.65,81.82 91.65,77.99 91.76,77.87 91.95,77.87 v2(92.15,78.07) ; v2(113.97,47.02) 113.97,45.87 114.41,45.44 114.41,44.06 114.28,43.93 DM2.32
M_B_DQS_DN2: length 62.7
  L5 w0.102: v2(119.14,49.04) 119.29,48.89 119.29,48.72 119.24,48.68 119.11,48.62 118.88,48.62 118.58,48.93 118.58,50.78 99.9,69.46 99.9,69.6 99.96,69.66 99.96,69.97 99.7,70.24 99.39,70.24 99.33,70.18 99.18,70.18 99.04,70.32 99.04,70.46 99.1,70.52 99.1,70.84 98.84,71.1 98.53,71.1 98.47,71.04 98.32,71.04 98.18,71.18 98.18,71.33 98.24,71.39 98.24,71.7 97.97,71.96 97.66,71.96 97.6,71.9 97.46,71.9 97.17,72.19 97.17,78.91 97.13,78.95 97.13,79.83 95.94,81.02 94.57,81.02 93.39,82.21 92.11,82.21 91.05,83.26 89.56,83.26 87.98,84.84 87.36,84.84 86.45,85.76 86.45,87.13 86.86,87.54 86.86,87.77 86.95,87.85 v2(87.18,87.85)
  BOTTOM w0.114: DM2.53 119.53,50.18 119.59,50.12 119.71,50.12 119.8,50.03 119.8,48.57 119.64,48.42 119.42,48.42 119.14,48.7 v2(119.14,49.04) ; CPU1.AL31 86.68,87.73 86.81,87.85 v2(87.18,87.85)
M_B_DQS_DN3: length 63.6
  L5 w0.102: v2(90.78,87.89) 90.58,87.89 90.53,87.85 90.53,87.58 90.34,87.38 90.34,87.04 91.69,85.69 91.7,85.69 92.31,85.08 93.59,85.08 94.86,83.81 96.76,83.81 97.49,83.08 98.38,83.08 98.86,82.6 98.86,82.51 98.86,82.33 101.28,79.91 101.28,75.43 107.24,69.47 107.24,67.81 125.41,49.63 125.41,48.87 125.35,48.81 125.35,48.03 125.41,47.98 125.41,47.41 125.16,47.17 v2(124.97,47.17)
  BOTTOM w0.114: v2(124.97,47.17) 125.18,46.96 125.18,44.4 125.05,44.27 124.89,44.27 124.78,44.15 DM2.74 ; CPU1.AU31 90.33,87.74 90.49,87.89 v2(90.78,87.89)
M_B_DQS_DN4: length 87.7
  L3 w0.089: v2(152.06,48.86) 152.08,48.63 152.28,48.44 152.83,48.44 153.13,48.74 153.13,50.3 141.49,61.94 109.46,61.94 102,69.39 100.06,69.39 97.39,72.06 97.39,76.12 97.22,76.3 96.92,76.3 v2(96.46,75.84)
  BOTTOM w0.076: 94.16,83.14 94.16,83.42 93.96,83.62 93.96,83.94 94.02,84.1 94.02,84.26 93.97,84.4 93.97,84.6 94.05,84.83 93.98,85.02 93.87,85.07 93.82,85.06 93.76,84.99 CPU1.BB35
  BOTTOM w0.114: DM2.177 152.53,50.07 152.8,49.8 152.8,48.77 152.51,48.49 152.19,48.49 152.06,48.61 v2(152.06,48.86) ; v2(96.46,75.84) 96.24,76.06 95.65,76.06 95.37,76.34 95.37,78.47 94.16,79.69 94.16,83.14
M_B_DQS_DN5: length 89.6
  L3 w0.089: v2(100.65,79.67) 101.39,78.93 101.39,78.52 102.39,77.52 102.39,75.29 111.04,66.65 111.04,66.36 110.75,66.07 110.75,65.91 110.87,65.79 111.02,65.79 111.32,66.08 111.6,66.08 112.41,65.27 142.92,65.27 158.19,50 158.19,49.43 158.49,49.13 158.49,47.03 157.97,46.51 157.38,46.51 v2(157.22,46.35)
  BOTTOM w0.076: CPU1.BF34 96.27,85.3 96.35,85.23 96.54,85.23 96.65,85.12 96.67,85.06 96.71,84.96 96.71,84.7 96.67,84.6 96.67,84.41 96.71,84.31 96.71,84.05 96.67,83.95 96.67,83.69 96.83,83.53 96.83,83.49
  BOTTOM w0.114: 96.83,83.49 96.86,83.46 96.86,82.28 99.67,79.48 100.47,79.48 v2(100.65,79.67) ; DM2.198 157.78,46.11 157.54,46.35 v2(157.22,46.35)
M_B_DQS_DN6: length 93.3
  L3 w0.089: v2(162.46,49.03) 162.46,48.85 162.59,48.72 163.07,48.72 163.22,48.88 163.22,49.89 161.35,51.77 159.95,51.77 144.03,67.69 128.71,67.69 127.93,68.47 118.31,68.47 116.46,70.32 114.14,70.32 113.06,71.4 112.94,71.4 112.55,71.01 112.26,71.01 112,71.28 112,71.56 112.39,71.95 112.39,72.08 112.24,72.23 112.11,72.23 111.72,71.84 111.44,71.84 111.17,72.11 111.17,72.39 111.56,72.78 111.56,72.91 102.7,81.77 102.01,81.77 99.5,84.27 97.09,84.27 96.76,84.41 95.01,86.17 95.01,86.64 94.71,86.93 94.71,87.08 94.63,87.17 v2(94.37,87.17)
  BOTTOM w0.114: v2(94.37,87.17) 94.37,87.41 94.27,87.5 CPU1.BC31 ; DM2.219 163.03,50.18 163.3,49.91 163.3,49.23 162.94,48.87 162.83,48.76 162.58,48.76 162.46,48.88 v2(162.46,49.03)
M_B_DQS_DN7: length 99.7
  L5 w0.102: v2(98.03,87.2) 98.19,87.2 98.32,87.07 98.32,86.87 98.49,86.7 98.49,85.99 99.25,85.22 99.84,85.22 100.78,84.29 103.03,84.29 104.98,82.34 104.98,76.41 110.55,70.85 110.55,69.2 125.8,53.95 143.33,53.95 144.03,53.25 165.04,53.25 167.03,51.25 167.03,45.65 167.33,45.35 167.62,45.35 167.81,45.16 v2(167.81,44.97)
  BOTTOM w0.089: v2(98.03,87.2) 98.03,87.41 97.94,87.5 CPU1.BH31
  BOTTOM w0.114: v2(167.81,44.97) 167.81,45.15 167.95,45.29 168.39,45.29 168.55,45.14 168.55,44.2 168.28,43.93 DM2.240
M_B_DQS_DP0: length 56.6
  L5 w0.102: v2(108.57,47.88) 108.89,48.2 109.09,48.2 109.36,48.48 109.36,49.44 107.11,51.7 102.55,51.7 102.26,51.99 102.26,52.13 102.56,52.43 102.56,52.74 102.29,53.01 101.98,53.01 101.68,52.71 101.54,52.71 101.4,52.85 101.4,52.99 101.69,53.29 101.69,53.6 101.4,53.9 101.06,53.9 100.79,53.63 100.61,53.63 89.53,64.72 89.53,74.5 89.25,74.77 89.25,80.74 88.83,81.16 v2(88.06,81.16)
  BOTTOM w0.076: CPU1.AP34 88.34,85.11 88.34,85.1 88.3,84.98 88.29,84.97 88.29,84.69 88.3,84.68 88.33,84.6 88.33,84.41 88.29,84.31 88.29,84.05 88.3,84.03 88.33,83.95 88.33,83.59 88.33,83.59 88.33,83.27 88.46,83.13 88.46,83.01 88.45,83 88.45,82.81
  BOTTOM w0.114: 88.45,82.81 88.45,81.29 88.33,81.16 v2(88.06,81.16) ; v2(108.57,47.88) 108.83,48.14 109.24,48.14 109.53,48.43 DM2.13
M_B_DQS_DP1: length 57.6
  L5 w0.102: v2(92.15,77.44) 92.42,77.7 92.89,77.7 93.35,77.24 93.35,68.8 104.5,57.65 104.5,57.51 104.23,57.24 104.23,56.93 104.5,56.67 104.81,56.67 105.07,56.93 105.22,56.93 105.36,56.79 105.36,56.64 105.1,56.38 105.1,56.07 105.36,55.8 105.67,55.8 105.94,56.07 106.59,56.07 106.69,55.97 106.69,55.68 106.91,55.46 107.29,55.46 107.51,55.68 107.51,55.97 107.61,56.07 108.01,56.07 114.29,49.8 114.29,47.96 v2(114.05,47.73)
  BOTTOM w0.076: CPU1.AV35 91.24,84.99 91.31,85.06 91.35,85.07 91.46,85.02 91.53,84.83 91.45,84.6 91.45,84.4 91.5,84.26 91.5,84.1 91.42,83.87 91.42,83.87 91.39,83.84 91.39,82.45 91.44,82.4 91.44,81.87 91.42,81.84 91.42,81.82
  BOTTOM w0.114: v2(114.05,47.73) 114.41,47.37 114.41,46.84 114.2,46.63 114.2,45.97 114.64,45.53 114.64,44.06 114.78,43.93 DM2.34 ; 91.42,81.82 91.42,77.89 91.67,77.64 91.95,77.64 v2(92.15,77.44)
M_B_DQS_DP2: length 62.6
  L5 w0.102: v2(87.08,88.48) 86.66,88.06 86.66,87.62 86.25,87.21 86.25,85.67 87.28,84.64 87.9,84.64 89.48,83.06 90.97,83.06 92.02,82.01 93.3,82.01 94.49,80.82 95.85,80.82 96.93,79.74 96.93,78.86 96.97,78.83 96.97,72.11 97.37,71.7 97.69,71.7 97.75,71.76 97.89,71.76 98.03,71.62 98.03,71.47 97.97,71.41 97.97,71.1 98.24,70.84 98.55,70.84 98.61,70.9 98.75,70.9 98.9,70.75 98.9,70.61 98.84,70.55 98.84,70.24 99.1,69.97 99.41,69.97 99.47,70.03 99.62,70.03 99.76,69.89 99.76,69.75 99.7,69.69 99.7,69.37 118.38,50.7 118.38,48.84 v2(119.03,48.19)
  BOTTOM w0.114: CPU1.AL30 v2(87.08,88.48) ; v2(119.03,48.19) 119.74,48.19 120.03,48.48 DM2.55
M_B_DQS_DP3: length 63.7
  L5 w0.102: v2(90.8,88.53) 90.33,88.06 90.33,87.67 90.13,87.47 90.13,86.96 91.61,85.49 91.62,85.49 92.23,84.88 93.5,84.88 94.78,83.61 96.68,83.61 97.41,82.88 98.3,82.88 98.66,82.52 98.66,82.43 98.66,82.25 101.07,79.83 101.07,75.35 107.03,69.39 107.03,67.72 125.21,49.55 125.21,48.95 125.15,48.89 125.15,48.11 v2(124.97,47.8)
  BOTTOM w0.114: CPU1.AU30 v2(90.8,88.53) ; DM2.76 125.28,44.17 125.41,44.31 125.41,47.37 v2(124.97,47.8)
M_B_DQS_DP4: length 87.7
  L3 w0.089: v2(152.11,48.04) 152.32,48.25 152.91,48.25 153.32,48.66 153.32,50.38 141.57,62.13 109.53,62.13 102.08,69.58 100.14,69.58 97.58,72.14 97.58,76.2 97.3,76.49 v2(96.5,76.49)
  BOTTOM w0.076: CPU1.BB34 93.76,85.39 93.89,85.26 93.94,85.24 93.95,85.23 94.12,85.15 94.24,84.83 94.14,84.57 94.14,84.43 94.19,84.29 94.19,84.07 94.14,83.9 94.14,83.69 94.29,83.54 94.34,83.49 94.34,83.29 94.36,83.26 94.36,83.16 94.39,83.14
  BOTTOM w0.114: v2(96.5,76.49) 96.3,76.29 95.75,76.29 95.6,76.43 95.6,78.57 94.39,79.78 94.39,83.14 ; v2(152.11,48.04) 152.66,48.31 153.03,48.67 DM2.179
M_B_DQS_DP5: length 89.6
  L3 w0.089: v2(157.23,46.98) 157.51,46.7 157.89,46.7 158.3,47.11 158.3,49.05 158,49.35 158,49.92 142.84,65.08 112.33,65.08 111.52,65.89 111.4,65.89 111.1,65.6 110.95,65.6 110.95,65.6 110.79,65.6 110.56,65.83 110.56,66.15 110.85,66.44 110.85,66.57 102.2,75.21 102.2,77.44 101.2,78.44 101.2,78.85 100.98,79.07 100.8,79.07 v2(100.65,78.93)
  BOTTOM w0.076: CPU1.BF35 96.27,84.97 96.35,85.05 96.47,85.05 96.49,85.02 96.53,84.93 96.53,84.73 96.49,84.63 96.49,84.38 96.53,84.28 96.53,84.08 96.49,83.98 96.49,83.62 96.63,83.48 96.63,83.48 96.63,83.37
  BOTTOM w0.114: v2(100.65,78.93) 100.33,79.25 99.57,79.25 96.63,82.19 96.63,83.37 ; DM2.200 158.28,43.81 158,44.08 158,46.21 v2(157.23,46.98)
M_B_DQS_DP6: length 93.3
  L3 w0.089: v2(162.91,48.3) 163.41,48.8 163.41,49.97 161.42,51.96 160.03,51.96 144.11,67.88 128.79,67.88 128,68.66 118.39,68.66 116.54,70.51 114.22,70.51 113.14,71.59 112.86,71.59 112.47,71.2 112.34,71.2 112.19,71.36 112.19,71.48 112.58,71.87 112.58,72.16 112.31,72.42 112.03,72.42 111.64,72.03 111.52,72.03 111.36,72.19 111.36,72.31 111.75,72.7 111.75,72.98 102.78,81.96 102.09,81.96 99.58,84.46 97.13,84.46 96.87,84.57 95.2,86.24 95.2,86.71 94.9,87.01 94.9,87.2 v2(94.43,87.89)
  BOTTOM w0.114: DM2.221 163.53,49.13 162.91,48.52 v2(162.91,48.3) ; CPU1.BC30 v2(94.43,87.89)
M_B_DQS_DP7: length 99.8
  L5 w0.102: v2(167.85,45.73) 167.67,45.55 167.42,45.55 167.24,45.73 167.24,51.34 165.12,53.45 144.11,53.45 143.41,54.15 125.88,54.15 110.75,69.28 110.75,70.93 105.18,76.5 105.18,82.42 103.11,84.49 100.86,84.49 99.93,85.43 99.33,85.43 98.69,86.07 98.69,86.79 98.53,86.95 98.53,87.28 v2(98.06,87.9)
  BOTTOM w0.114: v2(167.85,45.73) 168.06,45.52 168.49,45.52 168.78,45.24 DM2.242 ; CPU1.BH30 v2(98.06,87.9)
M_B_PARITY: length 89.8
  L3 w0.114: v2(138.53,53.21) 138.53,52.59 139.75,51.38 139.75,50.72 139.2,50.17 137.88,50.17 135.62,52.44 135.62,53.04 135.03,53.63 127.12,53.63 126.94,53.81 103.67,53.81 98.07,59.4 95.08,59.4 81.43,73.06 81.43,78.54 v2(82.31,79.42)
  BOTTOM w0.076: CPU1.AE34 83.04,85.58 82.73,85.27 82.73,84.22 82.62,84.02 82.62,83.62 82.81,83.44 82.81,83.07 82.42,82.68 82.42,81.05 82.44,81.03 82.44,80.64
  BOTTOM w0.14: v2(138.53,53.21) 138.54,53.21 140.77,53.21 142.03,51.96 DM2.143 ; 82.44,80.64 82.44,79.55 v2(82.31,79.42)
M_VREF_CA_DIMMA: length 1.3
  BOTTOM w0.254: DM1.164 73.08,41.81 v2(72.9,41.63)
  vias: v1(71.02,40.77)
M_VREF_CA_DIMMB: length 1.8
  BOTTOM w0.305: DM2.164 149.28,44.33 v2(149.02,44.58)
  vias: v1(147.45,42.42)
MASK_SATA_LED#: length 86.6
  TOP w0.089: U2401.56 34.35,57.16 34.57,56.94 34.57,55.52 34.45,55.4 v2(34.39,55.4) 34.39,54.86 34.08,54.55 32.56,54.55 31.13,53.12 31.13,50.73 32.25,49.61 32.25,47.35 31.95,47.05 31.53,47.05 31.27,46.79 31.27,46.44 31.63,46.08 31.63,44.25 31.27,43.89 29.49,43.89 28.37,45.01 27.69,45.01 27.59,44.91 27.31,44.63 27.31,41.09 26.26,40.04 26.26,36.7 25.53,35.97 v2(23.68,35.97) ; v2(62,41.64) v1(62.56,41.64)
  L5 w0.089: v2(62,41.64) 62,41.66 60.79,42.88 59.62,42.88 59.6,42.89 59.58,42.89 59.21,43.26 32.31,43.26 31.37,44.21 31.37,45.04 30.46,45.95 30.46,47.48 30.11,47.83 30.11,51.58 32.72,54.18 33.72,54.18 34.39,54.86 v2(34.39,55.4)
  BOTTOM w0.089: R6403.2 60.91,40.55 v2(62,41.64) ; v2(23.68,35.97) 22.28,35.97 21.76,35.44 Q6401.G
