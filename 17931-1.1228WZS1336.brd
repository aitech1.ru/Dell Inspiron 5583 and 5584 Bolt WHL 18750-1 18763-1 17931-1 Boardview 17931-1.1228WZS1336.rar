# Allegro board 17931-1.1228WZS1336.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP2_CTRL_CLK: length 34.5
  L5 w0.114: v2(113.8,111.51) 113.09,111.51 112.92,111.34 112.92,110.54 113.14,110.31 115.19,110.31 115.52,110.64 120.97,110.64 122.38,109.23 122.38,104.9 v2(121.93,104.45)
  BOTTOM w0.076: CPU1.CH4 109.27,105.13 109.27,106.35 109.57,106.64 109.57,107.24 110.94,108.62 111.54,108.62 112.27,109.35 112.27,109.91
  BOTTOM w0.114: 112.27,109.91 112.27,110.95 112.83,111.51 v2(113.8,111.51) 112.58,112.73 v1(112.58,114.35) ; v2(121.93,104.45) 121.93,104.16 122.27,103.82 124.22,103.82 124.59,104.19 RN401.7
CPU_DP2_CTRL_DATA: length 29.9
  L5 w0.114: v2(113.77,110.85) 113.81,110.88 121.07,110.88 122.62,109.33 122.62,104.73 122.54,104.64 v2(122.54,104.27)
  BOTTOM w0.076: 112.65,109.86 112.65,109.5 111.61,108.45 111.01,108.45 109.74,107.18 109.74,105.71 CPU1.CH3
  BOTTOM w0.114: 112.65,109.86 112.65,110.59 112.91,110.85 v2(113.77,110.85) 114.25,111.33 v1(114.25,114.3) ; v2(122.54,104.27) 122.54,104.27 123.4,104.27 123.91,104.78 RN401.8
CPU_DP2_HPD: length 20.6
  BOTTOM w0.076: CPU1.CM6 111.94,103.3 112.25,102.99 112.7,102.99 112.75,102.97 112.75,102.97 113.06,102.97 113.06,102.97 113.11,102.99 113.36,102.99 113.4,102.97 113.42,102.95 114.13,102.95
  BOTTOM w0.089: R403.2 125.15,99.39 124.72,99.82 124.13,99.82 123.85,100.1 123.85,101.22 ; Q401.6 126.66,101.64 R405.2 126.34,101.32 125.58,101.32 R404.1 125.43,101.42 124.06,101.42 123.85,101.22 ; 114.13,102.95 114.15,102.97 115.65,102.97 115.85,103.18 116.92,103.18 117.42,103.68 121.07,103.68 v1(122.84,101.91) 123.29,101.45 123.62,101.45 123.85,101.22
CPU_DP_HPD_MUX: length 2
  TOP w0.089: U7201.11 39.83,112.94 v1(39.47,113.29) 39.33,113.44 R7206.1
CPU_DP_HPD_R: length 54.7
  TOP w0.089: v2(27.48,111.02) 26.9,111.02 26.75,110.87 R7118.2 ; R7219.1 37.39,112.29 v2(37.88,112.78) 37.7,112.96 R7206.2 37.42,113.72 v1(37.42,114.33) 37.42,114.92 R7202.2 ; U5802.48 v2(47.7,120.97)
  L3 w0.089: v2(15.59,111.79) 15.9,111.79 17.2,110.49 19.87,110.49 20.16,110.49 20.8,109.86 26.17,109.86 27.33,111.02 v2(27.48,111.02)
  L5 w0.089: v2(37.88,112.78) 37.88,113.38 36.17,115.08 36.17,120.49 37.14,121.46 38.49,121.46 38.51,121.48 38.53,121.48 38.88,121.82 40.67,121.82 41.08,121.41 41.43,121.41 43.15,119.69 46.42,119.69 v2(47.7,120.97)
  BOTTOM w0.089: v2(27.48,111.02) 27.61,111.16 27.96,111.16 28.19,111.39 32.46,111.39 32.98,111.91 35.85,111.91 35.99,111.77 36.86,111.77 v2(37.88,112.78) ; v2(15.59,111.79) 15.75,111.79 16.94,110.59 R7176.2
CPU_POPIRCOMP: length 1.6
  TOP w0.114: R304.1 102.43,89.78 101.97,89.78 101.97,89.78 v2(101.75,89.78)
  BOTTOM w0.114: v2(101.75,89.78) 101.43,90.1 CPU1.BP27
CPU_SMB_SCL_THM: length 10
  TOP w0.114: v2(126.67,114.48) 126.67,114.59 U2601.8
  BOTTOM w0.114: v2(126.67,114.48) 126.25,114.48 R2617.2 125.25,113.48 v1(125.25,112.98) 125.5,112.73 128.09,112.73 129.46,111.35 129.46,110.82 Q2601.4
CPU_SMB_SDA_THM: length 10.3
  TOP w0.114: v2(126.98,113.84) 126.68,113.84 126.16,114.37 125.97,114.37 U2601.7
  BOTTOM w0.114: Q2601.1 131.98,110.14 131.98,110.72 130.94,111.76 130.72,111.76 130.23,111.76 130.08,111.91 129.47,111.91 129.01,112.37 129.01,112.37 128.96,112.42 v1(128.95,112.42) 128.95,112.43 128.74,112.64 128.74,113.31 128.53,113.52 128.53,113.84 128.02,114.35 R2618.2 127.38,114.25 v2(126.98,113.84)
CPVDD: length 6.7
  TOP w0.203: 29.17,10.35 28.95,10.35 28.33,10.97 HDA27.29
  TOP w0.381: C2704.1 30.86,7.7 R2709.2
  TOP w0.508: 29.17,10.35 29.61,9.91 v1(30.48,9.91) 30.57,9.91 31.6,8.88 C2705.1 31.6,8.33 C2704.1
CPVEE: length 4.1
  TOP w0.203: 27.53,10.75 HDA27.27
  TOP w0.305: C2709.1 29.16,8.61 v1(28.83,8.94) 28.55,9.22 28.55,9.72 27.53,10.75
CRT_AUX_CPU_N: length 198.9
  TOP w0.114: v2(59.52,121.11) 59.52,120.82 59.63,120.7 59.74,120.7 59.87,120.58 59.87,120.4 58.99,119.52 58.11,119.52 R5822.2 57.61,119.51 57.4,119.51 R5825.1
  L6 w0.102: v2(59.52,121.11) 59.72,120.91 59.72,120.9 59.75,120.88 59.75,120.62 60.01,120.35 60.99,120.35 61.71,121.07 63.44,121.07 64.17,120.35 86.17,120.35 87.87,122.05 89.46,122.05 90.06,122.65 101.4,122.65 102.46,121.59 105.85,121.59 109.51,117.93 110.75,117.93 114.35,114.32 114.35,112.82 115.2,111.97 116.99,111.97 118.39,110.56 120.91,110.56 122.29,109.18 122.29,105.15 123.38,104.06 123.38,102.79 123.75,102.41 123.75,100.08 124.39,99.44 124.39,92.91 124.95,92.35 124.95,81.16 124.74,80.96 124.74,73.61 127.59,70.77 128.7,70.77 131.35,68.12 159.18,68.12 160.39,66.92 170.63,66.92 170.67,66.88 170.68,66.88 171.06,66.5 172.28,66.5 172.47,66.31 175.98,66.31 177.91,64.37 177.91,62.93 178.79,62.05 178.79,60.95 182.56,57.18 190.75,57.18 192.16,58.6 197.94,58.6 198.27,58.27 198.27,57.42 v2(198.07,57.22)
  BOTTOM w0.114: v2(59.52,121.11) 59.52,120.69 R5831.1 ; VGABD1.14 197.95,58.16 198.09,58.03 198.09,57.77 198.28,57.58 198.28,57.43 v2(198.07,57.22)
CRT_AUX_CPU_N_R: length 3.2
  TOP w0.114: v2(59.29,118.67) 59.34,118.62 59.34,118.59 59.94,117.98 60.7,117.98 60.8,117.88 60.8,117.72 60.63,117.55 R5845.1
  BOTTOM w0.114: R5831.2 59.44,119.17 59.44,118.82 v2(59.29,118.67)
CRT_AUX_CPU_P: length 198.9
  TOP w0.114: v2(60.15,121.08) 60.15,120.35 59.09,119.29 58.13,119.29 R5823.2 57.61,119.28 57.37,119.28 R5824.1
  L6 w0.102: v2(60.15,121.08) 59.95,120.88 59.95,120.7 60.1,120.55 60.91,120.55 61.63,121.27 63.53,121.27 64.25,120.55 86.08,120.55 87.78,122.25 89.38,122.25 89.98,122.85 101.49,122.85 102.54,121.79 105.93,121.79 109.6,118.13 110.83,118.13 114.55,114.41 114.55,112.9 115.28,112.17 117.07,112.17 118.48,110.77 120.99,110.77 122.49,109.27 122.49,105.23 123.58,104.15 123.58,102.87 123.96,102.5 123.96,100.16 124.59,99.53 124.59,92.99 125.15,92.43 125.15,81.08 124.95,80.87 124.95,73.69 127.67,70.97 128.79,70.97 131.43,68.33 159.27,68.33 160.48,67.12 170.72,67.12 170.76,67.08 170.76,67.08 171.14,66.7 172.36,66.7 172.55,66.51 176.06,66.51 178.11,64.46 178.11,63.01 179,62.13 179,61.04 182.65,57.39 190.66,57.39 192.08,58.8 198.02,58.8 198.47,58.35 198.47,57.45 v2(198.71,57.22)
  BOTTOM w0.114: v2(198.71,57.22) 198.5,57.42 198.5,57.68 198.31,57.86 198.31,58.03 198.45,58.16 VGABD1.13 ; R5830.1 60.15,120.54 v2(60.15,121.08)
CRT_AUX_CPU_P_R: length 3.2
  TOP w0.114: R5844.1 60.79,118.21 60.04,118.21 59.83,118.42 59.83,118.58 v2(59.92,118.67)
  BOTTOM w0.114: R5830.2 59.72,119.24 59.72,118.87 v2(59.92,118.67)
CRT_DDI_TX_N0: length 208.1
  TOP w0.114: R5841.1 51.26,124.7 v2(51.26,125.2)
  L6 w0.102: v2(201.66,57.21) 201.37,57.5 201.37,58.78 201.12,59.03 200.16,59.03 198.97,60.22 191.51,60.22 189.89,58.6 184.18,58.6 179.28,63.5 179.28,64.94 176.54,67.68 173.04,67.68 172.84,67.87 171.64,67.87 171.16,68.35 160.99,68.35 159.13,70.21 131.33,70.21 129.4,72.14 128.2,72.14 126.11,74.23 126.11,80.28 126.32,80.49 126.32,95.33 125.76,95.89 125.76,104.02 125.38,104.4 125.38,108.95 122.18,112.15 122.18,112.98 120.63,114.52 119.13,114.52 116.39,117.26 116.39,118.85 112.44,122.8 111.37,122.8 110.48,123.69 103.24,123.69 102.26,124.66 87.68,124.66 85.34,122.33 64.99,122.33 64.19,123.13 54.6,123.13 53.11,124.61 51.26,124.61 51.04,124.82 51.04,124.98 v2(51.26,125.2)
  BOTTOM w0.114: VGABD1.7 201.45,58.22 201.31,58.08 201.31,57.81 201.38,57.74 201.38,57.49 v2(201.66,57.21)
CRT_DDI_TX_N1: length 203.2
  TOP w0.114: v2(56.92,121.3) 56.92,121.8 55.81,122.91 54.69,122.91 R5843.1
  L6 w0.102: v2(56.92,121.3) 56.92,121.55 57.05,121.68 57.22,121.68 57.35,121.8 57.35,122.3 57.6,122.54 63.95,122.54 64.75,121.74 85.59,121.74 87.29,123.45 88.67,123.45 89.27,124.04 102.06,124.04 103,123.1 110.02,123.1 110.97,122.15 112.17,122.15 115.17,119.15 115.17,117.66 118.88,113.94 120.39,113.94 121.57,112.76 121.57,111.93 123.73,109.77 123.73,107.29 124.31,106.71 124.31,105.19 124.79,104.71 124.79,104.12 125.17,103.74 125.17,95.62 125.73,95.06 125.73,80.82 125.53,80.62 125.53,73.97 127.94,71.55 129.09,71.55 131.7,68.94 159.52,68.94 160.72,67.74 170.93,67.74 171.38,67.29 172.6,67.29 172.79,67.1 176.3,67.1 178.7,64.7 178.7,63.26 183.96,57.99 190.27,57.99 191.89,59.62 198.59,59.62 199.6,58.6 199.6,57.71 199.73,57.59 200.03,57.59 200.2,57.41 v2(200.2,57.2)
  BOTTOM w0.114: v2(200.2,57.2) 199.86,57.55 199.86,58.12 199.95,58.22 VGABD1.10
CRT_DDI_TX_P0: length 208.2
  TOP w0.114: v2(50.63,125.22) 50.82,125.03 50.82,124.57 R5840.1
  L6 w0.102: v2(50.63,125.22) 50.84,125.01 50.84,124.74 51.17,124.41 53.03,124.41 54.52,122.92 64.11,122.92 64.91,122.12 85.43,122.12 87.76,124.46 102.18,124.46 103.16,123.48 110.39,123.48 111.28,122.59 112.35,122.59 116.18,118.76 116.18,117.18 119.04,114.32 120.55,114.32 121.97,112.9 121.97,112.06 125.17,108.86 125.17,104.32 125.56,103.94 125.56,95.8 126.11,95.24 126.11,80.57 125.91,80.37 125.91,74.14 128.12,71.93 129.32,71.93 131.25,70 159.05,70 160.9,68.15 171.08,68.15 171.56,67.67 172.76,67.67 172.95,67.48 176.46,67.48 179.08,64.86 179.08,63.41 184.1,58.4 189.97,58.4 191.6,60.02 198.89,60.02 200.08,58.83 201.04,58.83 201.17,58.7 201.17,57.5 v2(200.87,57.21)
  BOTTOM w0.114: v2(200.87,57.21) 201.15,57.49 201.15,57.65 201.09,57.72 201.09,58.07 200.95,58.21 VGABD1.8
CRT_DDI_TX_P1: length 202.3
  TOP w0.114: v2(57.55,121.31) 57.55,121.67 57.44,121.78 57.26,121.78 55.91,123.14 R5828.1
  L6 w0.102: v2(57.55,121.31) 57.55,122.21 57.68,122.34 63.86,122.34 64.66,121.54 85.67,121.54 87.37,123.24 88.76,123.24 89.36,123.84 101.97,123.84 102.91,122.9 109.93,122.9 110.89,121.95 112.09,121.95 114.96,119.07 114.96,117.57 118.8,113.74 120.31,113.74 121.36,112.68 121.36,111.85 123.53,109.68 123.53,107.21 124.11,106.63 124.11,105.11 124.59,104.62 124.59,104.04 124.97,103.66 124.97,95.53 125.53,94.98 125.53,80.91 125.33,80.71 125.33,73.88 127.86,71.35 129,71.35 131.62,68.73 159.44,68.73 160.63,67.54 170.84,67.54 171.3,67.08 172.52,67.08 172.71,66.89 176.22,66.89 178.49,64.62 178.49,63.17 183.88,57.79 190.35,57.79 191.98,59.41 198.5,59.41 199.4,58.52 v2(199.4,57.21)
  BOTTOM w0.114: VGABD1.11 199.45,58.21 199.63,58.03 199.63,57.44 v2(199.4,57.21)
CRT_DP_HPD: length 3.4
  TOP w0.089: v2(52.15,121.62) 51.7,121.17 U5802.38
  BOTTOM w0.089: v2(52.15,121.62) 52.26,121.62 v1(52.69,122.05) 52.95,122.31 53.25,122.31 R5605.2
CRT_DP_HPD_R: length 309.8
  TOP w0.089: v2(162.18,40.29) 162.18,40.31 162.59,40.72 165.65,40.72 166.59,39.78 169.09,39.78 170.08,40.77 171.28,40.77 172.78,42.27 175.95,42.27 176.2,42.52 176.2,47.3 AFTP5602.1 174.58,48.92 174.58,49.56 174.94,49.91 175.16,49.91 176.71,51.46 176.71,53.58 179.33,56.19 192.11,56.19 192.48,56.56 194.08,56.56 194.65,57.13 195.79,57.13 196.03,57.37 v2(196.03,57.82)
  L5 w0.089: v2(54.71,120.96) 54.71,118.24 53.45,116.97 53.45,116.52 48.85,111.91 48.49,111.91 47.91,111.33 45.88,111.33 45.22,110.67 45.22,108.54 43.94,107.26 43.94,105.9 44.61,105.24 44.61,98.42 41.54,95.35 41.54,80.4 42.19,79.75 42.19,77.72 42.19,77.43 41.49,76.74 41.49,76.74 40.67,75.91 40.67,73.36 38.92,71.6 38.92,70.73 37.11,68.93 34.04,68.93 31.07,65.96 31.07,61.06 26.87,56.86 26.87,54.58 25.21,52.92 25.21,51.42 23.57,49.78 23.57,48.33 22.9,47.66 22.9,47.05 22.02,46.18 22.02,33.49 22.33,33.18 24.68,33.18 27.16,35.66 30.93,35.66 31.8,36.52 31.94,36.52 31.95,36.52 34.14,36.52 35.41,37.79 35.41,39.83 38.2,42.62 52.97,42.62 55.12,40.46 59.57,40.46 60.92,39.11 65.61,39.11 66.54,40.05 90.26,40.05 90.77,40.56 101.12,40.56 101.87,41.31 101.87,41.61 103.64,43.38 105.41,43.38 105.84,43.81 110.1,43.81 111.22,44.93 127.39,44.93 129.65,42.67 132.22,42.67 132.62,42.27 140.9,42.27 141.74,41.42 144.96,41.42 145.63,42.09 160.38,42.09 v2(162.18,40.29)
  BOTTOM w0.089: v2(54.71,120.96) 54.46,121.21 54.46,122.55 R5605.1 ; VGABD1.18 195.95,57.9 v2(196.03,57.82)
CTL1: length 3.3
  TOP w0.089: U3601.6 18.9,51.94 18.72,52.12 18.72,52.66 v1(17.97,53.41) 17.04,53.41 R3601.2
CTL2: length 1.9
  TOP w0.089: v1(18.09,52.2) 18.44,51.85 R3606.2 18.75,51.31 18.88,51.44 U3601.7
CTL3: length 2
  TOP w0.089: U3601.8 18.83,50.94 R3602.2 v1(18.21,49.62)
DAT_ITE8010: length 4.3
  TOP w0.114: WWAN1.13 215.94,51.55 v1(214.94,52.55) 214.51,52.99 R2455.1
DAT_TP_SIO: length 139.4
  TOP w0.114: v2(101.39,41.43) 101.87,41.91 103.06,41.91 103.68,42.53 104.83,42.53 105.16,42.2 105.16,39.62 106.25,38.53 108.18,38.53 109.43,37.29 EC6501.1 109.41,37.12 RN6502.2 108.33,35.12 108.33,33.09 106.68,31.44 v1(106.68,31.04) 106.68,30.56 106.75,30.49 RN6501.4 ; U2401.79 37.64,65.69 v2(37.23,66.1)
  L3 w0.089: v2(101.39,41.43) 101.39,41.66 101.27,41.78 100.48,41.78 100.34,41.65 100.34,40.2 99.29,39.15 77.33,39.15 74.2,36.02 65.17,36.02 64.74,36.46 55.25,36.46 52.56,33.76 38.07,33.76 37.24,34.6 34.04,34.6 33.18,33.73 31.02,33.73 30.64,34.11 30.64,34.77 28.74,36.67 28.74,38.82 28.74,39 29.05,39.31 29.05,40.46 27.11,42.41 27.11,48.65 27.37,48.91 27.38,48.91 31.61,53.14 31.61,54.68 37.49,60.57 37.55,60.57 38.71,61.72 38.71,65.91 38.05,66.57 37.69,66.57 v2(37.23,66.1)
DBC_EN_R: length 29
  TOP w0.089: v2(214.6,62.84) 214.6,63.03 AFTP5522.1 214.05,63.57 R5504.2
  L3 w0.089: v2(214.6,62.84) 214.6,61.41 219.27,56.74 219.27,39.95 v2(219.71,39.52)
  BOTTOM w0.089: LCD1.34 219.22,40.55 219.71,40.06 v2(219.71,39.52)
DBC_PANEL_EN: length 131.9
  TOP w0.089: R5504.1 R2043.2 211.86,64.36 211.5,64.72 201.62,64.72 200.38,65.97 192.35,65.97 192.22,65.84 192.22,64.71 188,60.49 182.97,60.49 182.67,60.78 175.88,60.78 175.63,60.53 175.62,60.53 175.36,60.28 170.44,60.28 v1(168.32,58.16) v2(167.74,57.58)
  L5 w0.089: v2(167.74,57.58) 167.74,57.96 167.11,58.59 166.76,58.59 166.39,58.22 164.15,58.22 162.83,56.9 128.31,56.9 119.99,65.23 119.99,66 108.61,77.38 108.61,83.33 105.85,86.09 105.85,87.38 v2(105.41,87.82)
  BOTTOM w0.089: CPU1.CA31 105.5,87.82 v2(105.41,87.82)
DC_IN_OFF: length 3.4
  TOP w0.305: R4467.2 28.3,122.12 28.93,121.49 Q4449.6 29.9,121.39 29.9,121.74 30.12,121.97 R4470.2
DCBATOUT: length 52.8
  TOP w0.254: v2(111.59,123.24) 111.33,123.5 EC8923.1 FC8951.1
  TOP w0.305: FC8938.1 136.53,99.7 v2(136.53,101.65) ; FC8948.1 74.12,141.05 v4(74.2,140.97) ; v4(179.45,35.59) 179.33,35.46 FC8933.1 PC4443.1 ; PR4509.1 62.45,135.39 v2(62.45,136.16) ; FC8957.1 EC8962.1 141.71,38.33 142.07,37.97 v2(142.07,37.52) ; FC8955.1 210.9,40.21 v2(211.41,40.21) ; v2(211.41,41.96) 211.21,42.16 211.21,44.23 211.61,44.63 PR4477.1 ; v2(196.73,41.53) 196.57,41.53 196.37,41.33 EC8963.2 ; FC8952.1 126.83,110.2 v2(126.83,110.62) ; v4(181.17,34.75) 181.17,34.13 PC4406.1
  TOP w0.508: PR8552.1 142.12,75.61 141.61,76.12 v2(141.61,76.4)
  L6 w0.305: v2(60.73,141.53) 61.37,142.17 64.7,142.17 67.08,144.55 67.08,148.41 66.21,149.29 66.21,150.56 66.69,151.04 67.68,151.04 67.89,150.83 72.52,150.83 76.58,154.89 v2(76.58,154.99)
  BOTTOM w0.254: PC4522.1 38.14,33.58 36.92,34.8 FC8921.1 36.4,34.93 36.4,36.63 PR4511.1 ; R5551.2 139.53,88.88
  BOTTOM w0.305: v2(76.58,154.99) 76.91,154.66 PR4612.1
  BOTTOM w0.508: v2(196.73,41.53) 197.12,41.13 PD4401.2
  vias: v1(40.85,33.25) v1(40.77,32.01) v1(44.76,30.48) v1(47.98,30.19) v2(63.43,137.48) v2(63.46,138.12) v2(64.12,138.72) v2(64.1,138.08) v2(175.56,64.16) v4(74.2,140.13) v4(75.03,140.97) v4(75.03,140.13) v4(76.84,33.71) v4(77.68,33.71) v4(78.51,33.71) v4(79.35,33.71) v4(96.27,143.31) v4(96.27,142.47) v4(96.27,141.63) v4(109.21,137.72) v4(110.09,137.72) v4(112.19,144.15) v4(112.53,144.93) v4(123.68,35.33) v4(124.51,35.33) v4(126.6,35.28) v4(138.46,87.3) v4(138.46,86.41) v4(138.46,85.4) v4(138.51,84.38) v4(138.51,83.52) v4(157,87.17) v4(157,86.34) v4(157,85.5) v4(157,84.61) v4(157,83.77) v4(174.89,64.47) v4(175.02,63.48) v4(175.02,62.62) v4(175.02,61.78) v4(175.85,63.47) v4(175.85,62.61) v4(175.85,61.77) v4(179.49,34.75) v4(180.32,35.59) v4(180.33,34.75) v4(181.16,35.59) v4(181.99,35.59) v4(182,34.74) v4(184.89,38.81) v4(184.89,37.11)
DCBATOUT_LCD: length 136.1
  L5 w0.127: 225.1,51.46 225.1,63.86 221.72,67.24 210.57,67.24 209.73,66.4 199.88,66.4 199.86,66.38 199.85,66.38 198.02,64.56 196.73,64.56 195.84,65.44 193.54,65.44 193.28,65.18 193.28,64.82 193.02,64.56 189.32,64.56 187.85,63.09 184.74,63.09 182.86,64.97 182.86,66.83 181.26,68.43 180.8,68.43 180.7,68.43 179.17,69.96 179.17,70.77 177.47,72.47 176.83,72.47 173.41,75.9 171.95,75.9 170.4,74.34 169.78,74.34 169.41,74.72 168.1,74.72 166.02,76.8 163.44,76.8 162.08,78.16 160.89,78.16 157.68,74.95 138.62,74.95 136.17,77.4 v2(136.17,77.81)
  L5 w0.254: 225.1,51.46 225.1,49.51 v2(224.77,49.18)
  L6 w0.254: v2(224.77,49.18) 224.77,48.34 225.6,47.51 225.6,44.47 222.84,41.71 222.84,40.75 220.44,38.36 219.86,38.36 219.73,38.23 v2(219.71,38.23)
  BOTTOM w0.152: v2(136.17,77.81) 136.07,77.91 C5528.1 136.07,78.6 D5504.A
DCBATOUT_LCD_PG: length 105
  TOP w0.089: v2(119.05,80.27) 118.14,80.27 118.01,80.14 118.01,78.96 117.12,78.07 117.12,72.95 v1(114.97,70.79) 114.41,70.24 114.41,69.1 106.4,61.09 100.99,61.09 100.71,60.82 99.65,60.82 99.49,60.98 52.7,60.98 51.44,59.72 50.7,59.72 49.99,60.43 Q5505.1
  BOTTOM w0.089: R5546.2 134.45,77.88 134.95,77.37 134.95,76.92 134.66,76.63 133.12,76.63 133.05,76.55 132.71,76.55 132.44,76.28 132.44,75.4 132.18,75.14 130.91,75.14 128.5,77.55 124.08,77.55 123.73,77.9 121.42,77.9 v2(119.05,80.27)
DCBATOUT_LCD_PWRGD: length 21.1
  BOTTOM w0.089: C5531.1 137.01,92.33 136.86,92.48 R5554.1 ; C5531.1 137.44,92.33 138.25,93.14 v1(138.25,93.22) 138.26,93.22 138.56,93.52 R5555.1 ; C5531.1 137.34,91.8 137.66,91.48 137.66,90.1 137.87,89.89 137.87,89.1 137.52,88.75 134.86,88.75 134.55,88.44 134.55,85.31 133.66,84.42 133.66,80.8 134.78,79.68 D5504.K
DDR4_DRAMRST#: length 104.4
  TOP w0.089: v2(84.53,41.37) 83.68,42.22 81.36,42.22 78.15,39.01 75.06,39.01 73.57,37.52 70.74,37.52 69.32,38.94 61,38.94 60.56,39.37 C501.1 58.55,39.47 v2(57.41,39.47) ; v1(133.3,46.48) v2(133.84,46.28) 134.45,45.67 134.45,44.35 134.8,43.99 R504.2
  L6 w0.089: v2(131.21,41.33) 131.21,42.11 131.09,42.24 129.06,42.24 126.3,45 111.19,45 109.67,43.49 107.7,43.49 105.29,41.07 103.92,41.07 103.44,40.59 94.19,40.59 93.88,40.9 90.79,40.9 90.76,40.87 90.6,40.87 90.22,40.48 89.18,40.48 89.17,40.49 87.55,40.49 87.54,40.48 85.42,40.48 v2(84.53,41.37)
  BOTTOM w0.089: DM1.108 57.08,42.01 56.85,41.78 56.85,40.9 57.12,40.63 ED1217.1 57.61,39.68 v2(57.41,39.47) 57.61,39.27 ED1217.2 ; v2(133.84,46.28) 133.28,45.72 DM2.108 133.28,42.9 133.28,41.94 133.15,41.81 131.37,41.81 131.21,41.65 v2(131.21,41.33) 131.14,41.33 130.66,41.81 129.39,41.81 129.04,41.45 129.04,40.65 129.45,40.23 ED1302.1 ED1302.2
DGPU_HOLD_RST#: length 36
  L5 w0.089: v2(139.68,98.02) 139.12,98.02 138.15,97.05 137.26,97.05 136.25,96.05 136.25,93.65 135.03,92.43 v2(134.47,92.43)
  BOTTOM w0.089: U7601.1 138.36,97.1 138.85,96.6 R2054.2 139.56,95.91 EC2002.1 139.68,96.03 v2(139.68,98.02) ; CPU1.CR22 113.63,93.37 113.7,93.42 114.5,93.42 114.77,93.16 114.82,93.11 115.14,93.07 115.86,92.36 120.27,92.36 120.4,92.23 121.57,92.23 v1(121.67,92.33) 121.67,92.33 125.39,92.33 125.52,92.45 125.52,92.59 125.84,92.91 127.56,92.91 127.84,92.64 128.98,92.64 129.44,92.18 134.22,92.18 v2(134.47,92.43)
DGPU_PWR_EN: length 100.5
  TOP w0.089: v2(118.98,133.2) 118.84,133.2 115.02,129.38 115.02,127.52 116.8,125.74 117.97,125.74 120.45,123.26 v2(120.45,122.23) ; v2(100.21,144.2) 99.19,143.18 98.68,143.18 98.05,143.82 R8808.2 ; v2(128.25,90.86) 128.67,91.29 128.67,92.66 128.37,92.96 128.37,97.8 128.83,98.25 128.83,101.22 129.5,101.89 129.64,101.89 129.94,102.19 129.94,104.78 129.48,105.25 R2055.2 128.79,107.02 129.09,107.32 v2(129.09,110.06)
  L5 w0.089: v2(120.45,122.23) 121.32,122.23 123.69,119.85 123.69,119.53 125.87,117.35 127.32,117.35 129.92,114.76 129.92,113.7 129.09,112.87 v2(129.09,110.06)
  L6 w0.089: v2(118.98,133.2) 118.98,136.75 116.52,139.21 112.28,139.21 111.46,140.04 109.68,140.04 107.04,142.68 104.46,142.68 102.69,144.45 100.46,144.45 v2(100.21,144.2)
  BOTTOM w0.076: 115.2,91.83 114.91,92.13 113.86,92.13 113.74,92.25 113.44,92.25 113.38,92.23 113.08,92.23 113.02,92.25 112.49,92.25 112.41,92.34 111.86,92.34 CPU1.CM24
  BOTTOM w0.089: 115.2,91.83 115.37,91.67 115.42,91.62 119.21,91.62 119.69,91.14 v1(120.02,91.14) 120.21,90.94 127.15,90.94 127.23,90.86 v2(128.25,90.86)
DGPU_PWR_EN_1: length 4.2
  TOP w0.089: U8801.1 97.19,144.2 R8808.1 97.18,143.79 97.49,143.49 97.49,143.26 v1(97.59,143.16) 97.84,142.91 98.01,142.91 98.17,142.76 98.17,142.08 97.98,141.9 U8802.1
DGPU_PWR_EN_2: length 9.4
  TOP w0.089: U8801.2 97.6,145.94 98.94,144.6 v2(98.94,144.2) v1(98.94,143.56)
  BOTTOM w0.089: C8804.1 101.96,142.34 R8803.2 101.56,142.37 101.18,142.76 98.69,142.76 D8801.A 98.94,143.9 v2(98.94,144.2)
DGPU_PWROK: length 248.2
  TOP w0.089: v2(33.28,22.73) 35.89,25.34 35.89,27.31 39.58,31 50.15,31 50.29,31 50.29,31 50.84,31 53.31,33.47 53.97,34.13 53.97,36.01 53.28,36.7 53.28,40.18 54.16,41.06 54.16,41.76 54.16,41.76 54.16,42.57 53.57,43.15 53.57,49.76 57.66,53.85 111.36,53.85 127.53,70.02 127.53,70.29 127.53,73.38 127.09,73.83 127.09,76.64 v2(127.52,77.07) 129.14,78.69 129.14,85.69 129.69,86.25 129.69,94.38 129.39,94.68 129.39,97.37 130.26,98.24 130.41,98.24 130.86,98.69 130.86,99.96 130.25,100.56 v2(130.08,100.56) v1(130.31,101.17)
  L3 w0.089: v2(21.31,59.74) 21.31,59.01 18.68,56.38 18.68,49.95 18.39,49.66 18.39,43.27 17.81,42.7 17.81,30.12 23.3,24.64 30.2,24.64 30.69,24.16 30.69,22.89 31.17,22.4 32,22.4 32.25,22.65 32.25,22.7 32.47,22.91 33.09,22.91 v2(33.28,22.73) ; v2(127.52,77.07) 127.23,76.79 126.42,76.79 123.75,79.45 123.75,85.14 122.25,86.64 120.23,86.64 v2(119.41,87.46)
  BOTTOM w0.089: CPU1.CJ25 110.31,90.94 111.03,90.22 111.43,90.22 111.81,89.84 112.05,89.84 112.27,90.06 112.27,90.23 112.49,90.45 114.87,90.45 115.04,90.27 117.55,90.27 118.56,89.27 118.56,88.31 v2(119.41,87.46) ; v2(21.31,59.74) 22.25,58.8 R2471.1 ; v2(130.08,100.56) 131.12,100.56 131.77,99.9 132.77,99.9 133.23,100.36 136.86,100.36 137.47,99.75 U7302.4
DGPU_TXN_CPU_RXN0: length 7.4
  L5 w0.102: v2(122.98,137.88) 123.31,137.88 123.62,137.57 123.62,136.72 124.62,135.73 124.62,135.06 124.96,134.72 124.96,134.71 125.33,134.34 v2(125.91,134.34)
  BOTTOM w0.114: v2(125.91,134.34) 125.95,134.3 GPU1.AB9 ; v2(122.98,137.88) 122.98,138.17 122.42,138.72 C7602.2
DGPU_TXN_CPU_RXN1: length 7.3
  L5 w0.102: v2(125.96,135.54) 125.72,135.79 125.72,135.92 124.58,137.06 124.58,138.75 125.01,139.18 125.01,139.36 124.85,139.52 124.67,139.52 v2(124.57,139.42)
  BOTTOM w0.114: v2(125.96,135.54) 126.06,135.44 126.06,135.07 GPU1.AC10 ; C7604.2 123.69,140.04 124.32,139.42 v2(124.57,139.42)
DGPU_TXN_CPU_RXN2: length 6.7
  L5 w0.102: v2(126.52,136.11) 126.52,136.68 126.14,137.06 126.14,140.01 125.61,140.53 v2(125.61,140.62)
  BOTTOM w0.114: C7606.2 124.8,141.46 125.61,140.65 v2(125.61,140.62) ; v2(126.52,136.11) 126.52,136.1 GPU1.AC11
DGPU_TXN_CPU_RXN3: length 8
  L5 w0.102: v2(127.7,136.1) 127.56,136.23 127.56,136.83 127.28,137.11 127.28,141.19 v2(126.73,141.74)
  BOTTOM w0.114: C7608.2 125.93,142.29 126.49,141.74 v2(126.73,141.74) ; GPU1.AB12 127.71,136.09 v2(127.7,136.1)
DGPU_TXP_CPU_RXP0: length 6.4
  L5 w0.102: v2(125.35,134.91) 125.05,134.91 124.82,135.15 124.82,135.82 123.83,136.81 123.83,137.65 123.52,137.96 123.52,137.97 123.43,138.06 v2(123.43,138.33)
  BOTTOM w0.114: 122.56,139.28 122.56,138.91 123.14,138.33 v2(123.43,138.33) ; GPU1.AC9 125.36,134.9 v2(125.35,134.91)
DGPU_TXP_CPU_RXP1: length 7.6
  L5 w0.102: v2(126.47,134.95) 125.92,134.95 125.51,135.36 125.51,135.83 124.38,136.97 124.38,138.71 v2(124.12,138.97)
  BOTTOM w0.114: v2(126.47,134.95) 126.52,134.9 GPU1.AB10 ; v2(124.12,138.97) 124.12,139.13 124.12,139.29 123.43,139.97 123.25,139.97 C7603.2
DGPU_TXP_CPU_RXP2: length 7
  L5 w0.102: v2(125.16,140.17) 125.06,140.07 125.06,139.89 125.18,139.77 125.36,139.77 125.63,140.05 125.81,140.05 125.94,139.92 125.94,136.98 126.04,136.87 126.04,136.73 125.95,136.64 v2(125.95,136.64)
  BOTTOM w0.114: v2(125.16,140.17) 125.16,140.78 124.87,141.07 124.35,141.07 C7605.2 ; GPU1.AD11 v2(125.95,136.64)
DGPU_TXP_CPU_RXP3: length 8
  L5 w0.102: v2(126.28,141.29) 126.15,141.16 126.15,140.98 126.28,140.86 126.46,140.86 126.8,141.2 126.98,141.2 127.08,141.11 127.08,136.7 v2(127.11,136.67)
  BOTTOM w0.114: C7607.2 125.81,142.09 126.28,141.62 v2(126.28,141.29) ; GPU1.AC12 v2(127.11,136.67)
DMIC_CLK_EDP: length 20.9
  TOP w0.114: RN5504.2 212.43,41.63 211.67,42.38 211.67,43.76 212.41,44.5 212.83,44.5 213.22,44.88 AFTP5510.1 215.28,44.88 EC5504.1 215.69,45.14 218.11,45.14 218.29,45.32 218.29,46.21 219.56,47.49 220.21,47.49 v2(220.22,47.5) 221.89,45.83 RN5505.1
  BOTTOM w0.114: v2(220.22,47.5) 220.22,46.76 220.07,46.61 219.46,46.61 219.4,46.55 LCD1.22
DMIC_DATA_EDP: length 18.5
  TOP w0.114: RN5504.1 213.08,42.23 212.51,42.8 AFTP5509.1 211.92,43 211.92,43.66 212.25,44 212.9,44 EC5503.1 213.38,44.47 217.78,44.47 218.53,45.22 218.53,46.11 219.47,47.05 v2(219.76,47.05) 219.82,47.05 221.24,45.63 RN5505.2
  BOTTOM w0.114: LCD1.21 v2(219.76,47.05)
DMIC_PCH_CLK: length 158.7
  TOP w0.114: v1(127.74,88.9) 128.04,88.6 v2(128.22,88.6) ; v2(224.44,42.27) 224.36,42.19 222.6,42.19 222.34,41.94 RN5505.4
  L5 w0.114: v2(224.44,42.27) 223.28,42.27 222.28,43.27 222.28,52.79 223.14,53.65 223.14,60.91 219.61,64.44 219.41,64.44 219.41,64.44 200.43,64.44 198.19,62.2 190.19,62.2 188.69,60.7 184.03,60.7 180.28,64.45 180.28,64.61 180.28,64.61 180.28,64.81 175.6,69.5 173.59,69.5 172.9,70.18 164.61,70.18 163.75,71.04 132.12,71.04 129.04,74.12 129.04,87.78 128.22,88.6 v2(128.22,88.6)
  BOTTOM w0.076: 115.05,91.43 114.69,91.79 113.75,91.79 113.7,91.74 113.42,91.74 113.41,91.75 113.38,91.77 113.16,91.99 113.14,92 CPU1.CP24
  BOTTOM w0.114: v2(128.22,88.6) 128.22,88.6 127.57,89.24 127.57,89.91 126.95,90.53 119.66,90.53 119.53,90.67 119.53,90.67 119.01,91.19 115.29,91.19 115.05,91.43
DMIC_PCH_DATA: length 160.9
  TOP w0.114: v1(127.74,87.63) 128.08,87.97 v2(128.22,87.97) ; v2(224.41,41.58) 224.04,41.95 222.75,41.95 222.23,41.43 221.43,41.43 221.24,41.61 RN5505.3
  L5 w0.114: v2(224.41,41.58) 223.97,42.03 223.18,42.03 222.04,43.17 222.04,52.89 222.89,53.75 222.89,60.81 219.51,64.2 200.53,64.2 198.29,61.96 190.31,61.96 188.81,60.46 183.92,60.46 180.04,64.34 180.04,64.71 175.54,69.22 173.38,69.22 172.66,69.94 164.51,69.94 163.74,70.71 132.1,70.71 128.8,74.02 128.8,87.39 128.22,87.96 v2(128.22,87.97)
  BOTTOM w0.076: 114.86,91.26 114.5,91.62 113.89,91.62 113.85,91.58 113.35,91.58 113.31,91.62 113.28,91.63 113.19,91.72 112.62,91.72 CPU1.CN24
  BOTTOM w0.114: 114.86,91.26 115.22,90.91 118.94,90.91 119.56,90.29 126.85,90.29 127.33,89.81 127.33,88.85 128.22,87.97 v2(128.22,87.97)
DMIC_SCL_CODEC: length 213.7
  TOP w0.114: RN5504.3 212.43,40.27 211.28,39.12 209.03,39.12 207.71,37.8 205.49,37.8 v1(205.24,37.54) 205.12,37.43 205.12,35.75 204.73,35.36 v2(204.73,33.45) ; R2738.1 27.79,18.36 28.26,17.89 28.26,17.82 28.55,17.53 EC2707.1 28.55,17.33 v2(28.14,16.92)
  L5 w0.114: v2(28.14,16.92) 28.62,17.4 30.3,17.4 31.21,16.49 32.02,16.49 33.73,18.2 33.73,19.97 35.37,21.61 35.37,21.82 40.87,27.32 45.97,27.32 46.44,27.8 106.9,27.8 111.1,32 111.1,33.55 112.07,34.53 112.07,36.65 112.46,37.03 112.46,40.65 112.9,41.09 121.85,41.09 124.43,38.51 125.94,38.51 126.57,37.88 126.57,37.45 130.02,34.01 130.62,34.01 133.09,31.54 171.07,31.54 172.01,32.48 173.87,32.48 174.8,31.55 197.34,31.55 198.73,32.95 202.7,32.95 203.08,33.33 203.46,33.33 203.84,32.95 204.22,32.95 v2(204.73,33.45)
DMIC_SCL_CODEC_R: length 1.4
  TOP w0.114: R2738.2 27.7,17.44 27.7,16.74 27.93,16.52 HDA27.3
DMIC_SDA_CODEC: length 211.7
  TOP w0.114: EC2708.1 29.31,16.93 v2(29.3,16.91) 28.75,16.91 28.33,16.49 HDA27.2 ; RN5504.4 v1(213.08,39.45) 212.51,38.88 209.13,38.88 205.36,35.1 v2(205.36,33.45)
  L5 w0.114: v2(29.3,16.91) 29.39,17 30.35,17 31.12,16.23 32.11,16.23 34.01,18.13 34.01,19.87 35.46,21.33 35.46,21.36 35.61,21.51 35.61,21.72 40.97,27.08 46.07,27.08 46.54,27.56 107,27.56 111.34,31.9 111.34,33.45 112.7,34.81 112.7,40.36 113.19,40.85 121.61,40.85 124.46,38 125.68,38 129.92,33.76 130.5,33.76 132.97,31.29 171.17,31.29 172.11,32.23 173.77,32.23 174.7,31.31 197.44,31.31 198.5,32.37 204.28,32.37 v2(205.36,33.45)
DOCK_USB_EN_A: length 17.2
  TOP w0.089: v1(37.44,108.51) 37.53,108.51 v2(37.92,108.9) 38.18,109.16 U7201.18 ; U7102.16 v2(31.6,119.67)
  L5 w0.089: v2(37.92,108.9) 37.34,109.49 37.34,111.44 37.19,111.59 37.19,112.09 37.24,112.13 37.24,113 35.49,114.75 35.49,118.49 34.72,119.25 v2(34.72,119.71)
  BOTTOM w0.089: v2(34.72,119.71) 34.69,119.67 v2(31.6,119.67)
DOCK_USB_EN_B: length 10.1
  TOP w0.089: v2(37.85,111.81) 38,111.66 U7201.13 ; U7102.10 v2(35.41,119.19)
  L5 w0.089: v2(37.85,111.81) 37.42,112.24 37.42,113.08 37.21,113.28 37.21,113.67 35.87,115.01 35.87,118.73 v2(35.41,119.19)
DP2_AUX_C_N: length 7.9
  TOP w0.114: R7104.2 R7101.2 25.89,113.1 23.79,111 23.08,111 21.8,109.72 U7101.25
DP2_AUX_C_P: length 7.9
  TOP w0.114: U7101.24 22.2,109.19 22.03,109.36 22.03,109.63 23.17,110.77 23.88,110.77 25.99,112.88 26.3,112.88 26.5,112.68 R7102.2 26.71,112.74 27.07,112.74 R7103.2
DP2_AUX_CPU_N: length 46.6
  TOP w0.114: R5845.2 60.87,116.44 60.87,116.13 61.57,115.43 61.57,114.54 61.24,114.21 59.08,114.21 58.97,114.32 58.97,115.06 59.08,115.17 v2(59.17,115.17) 59.17,116.12 58.71,116.58 58.37,116.58 58.35,116.6 C5854.1
  BOTTOM w0.076: 83.48,108.89 83.47,108.88 83.43,108.88 82.82,108.27 82.82,106 82.84,105.94 82.95,105.61 82.95,105.36 CPU1.AD4
  BOTTOM w0.114: v2(59.17,115.17) 59.48,114.87 60.14,114.2 63.86,114.2 67.26,117.6 80.7,117.6 83.77,114.53 83.77,109.19 83.48,108.89
DP2_AUX_CPU_P: length 47.4
  TOP w0.114: R5844.2 61.29,116.69 61.1,116.49 61.1,116.23 61.8,115.52 61.8,114.44 61.34,113.98 58.99,113.98 58.74,114.23 58.74,114.97 v2(58.54,115.17) 58.54,115.37 58.94,115.77 58.94,116.02 58.61,116.35 58.02,116.35 57.89,116.22 C5862.1
  BOTTOM w0.076: 83.32,109.06 83.31,109.04 83.31,109.01 82.75,108.45 82.64,108.34 82.64,105.97 82.67,105.89 82.7,105.81 CPU1.AD3
  BOTTOM w0.114: v2(58.54,115.17) 58.54,114.66 58.66,114.53 59.49,114.53 60.05,113.97 63.95,113.97 67.36,117.37 80.6,117.37 83.54,114.43 83.54,109.28 83.32,109.06
DP2_DDI_TX_C_N2: length 20.8
  TOP w0.114: R5856.1 52.48,109.99 52.2,109.7 v2(50.96,109.7)
  BOTTOM w0.114: C5806.2 60.59,117.47 60.33,117.21 60.33,116.89 60.05,116.61 57.61,116.61 56.52,115.52 56.52,114.48 53.8,111.76 50.63,111.76 50.02,111.14 50.02,110.26 50.4,109.88 v2(50.96,109.7)
DP2_DDI_TX_C_N2_R: length 2.4
  TOP w0.114: R5856.2 52.2,113.74 52.2,113.95 51.81,114.33 51.81,114.81 51.7,114.92 U5802.13
DP2_DDI_TX_C_N3: length 15.1
  TOP w0.114: v2(53.94,111) 53.94,111.31 53.82,111.43 53.61,111.43 53.54,111.5 53.54,111.81 53.74,112.01 53.74,112.33 R5858.1
  BOTTOM w0.114: C5808.2 62.61,115.9 57.89,115.9 57.22,115.23 57.22,113.29 54.47,110.54 53.87,110.54 53.75,110.66 53.75,110.81 v2(53.94,111)
DP2_DDI_TX_C_N3_R: length 2.5
  TOP w0.114: U5802.16 52.9,114.95 52.94,114.91 52.94,114.43 53.47,113.89 53.57,113.89 R5858.2
DP2_DDI_TX_C_P2: length 20.9
  TOP w0.114: v2(50.96,110.34) 51.14,110.53 51.39,110.53 51.52,110.4 51.52,110.06 51.65,109.93 52.1,109.93 52.25,110.08 52.25,112.01 52.12,112.14 51.84,112.14 51.72,112.26 R5855.1
  BOTTOM w0.114: v2(50.96,110.34) 50.7,110.08 50.52,110.08 50.24,110.36 50.24,111.05 50.73,111.53 53.89,111.53 56.75,114.38 56.75,115.43 57.7,116.38 60.14,116.38 60.56,116.8 60.56,117.11 60.68,117.24 60.98,117.24 61.09,117.13 C5805.2
DP2_DDI_TX_C_P2_R: length 2.4
  TOP w0.114: R5855.2 51.97,113.72 51.97,113.85 51.58,114.24 51.58,114.71 51.3,115 U5802.12
DP2_DDI_TX_C_P3: length 15.2
  TOP w0.114: R5857.1 53.51,112.33 53.51,112.1 53.31,111.91 v2(53.31,111.02)
  BOTTOM w0.114: v2(53.31,111.02) 53.52,110.81 53.52,110.57 53.78,110.31 54.57,110.31 57.45,113.19 57.45,115.14 57.98,115.67 62.59,115.67 C5807.2
DP2_DDI_TX_C_P3_R: length 2.3
  TOP w0.114: U5802.15 52.5,115.02 52.71,114.81 52.71,114.33 53.24,113.8 R5857.2
DP2_DDI_TX_N0: length 54.1
  TOP w0.114: v2(46.99,110.54) 46.82,110.71 46.82,111 46.95,111.13 C5804.1
  BOTTOM w0.076: 81.8,108.46 81.8,108.45 81.82,108.42 81.82,107.44 81.89,107.37 81.89,106.92 81.7,106.73 81.7,106.35 81.71,106.32 81.73,106.27 81.73,106.05 81.7,105.97 81.7,105.67 81.72,105.66 81.79,105.49 81.86,105.34 81.88,105.29 81.88,104.66 82.01,104.53 CPU1.AC4
  BOTTOM w0.114: 81.8,108.46 81.8,109.27 82.13,109.61 82.13,113.64 79.85,115.93 68.05,115.93 64,111.87 63.86,111.74 63.74,111.74 57.97,111.74 53.83,107.6 49.99,107.6 49.1,108.48 48.57,108.48 48.14,108.92 48.14,110.98 47.79,111.33 46.74,111.33 46.59,111.18 46.59,110.95 v2(46.99,110.54)
DP2_DDI_TX_N1: length 50.4
  TOP w0.114: C5802.1 50.4,111.41 50.4,110.9 49.45,109.96 49.01,109.96 v2(48.85,109.79)
  BOTTOM w0.076: CPU1.AC1 82.28,106.63 82.28,108.59 82.25,108.61 82.25,108.63
  BOTTOM w0.114: 82.25,108.63 82.25,108.86 82.83,109.44 82.83,114.06 80.21,116.68 67.7,116.68 63.45,112.43 63.27,112.43 57.68,112.43 53.62,108.38 50.22,108.38 49.46,109.15 49.46,109.83 49.32,109.97 49.02,109.97 v2(48.85,109.79)
DP2_DDI_TX_N2: length 37.2
  BOTTOM w0.076: CPU1.AE4 83.49,105 83.54,105.11 83.57,105.42 83.69,105.69 83.69,105.97 83.66,106.05 83.66,106.27 83.68,106.32 83.69,106.35 83.69,106.82 83.52,107 83.52,107.48 84.65,108.61 84.68,108.61 84.7,108.63
  BOTTOM w0.114: 84.7,108.63 85.22,109.15 85.22,115.56 81.7,119.08 66.28,119.08 64.88,117.68 C5806.1
DP2_DDI_TX_N3: length 32.7
  BOTTOM w0.076: 84.28,108.92 84.27,108.9 84.23,108.9 83.18,107.85 83.18,107.06 83.17,107.06 83.17,106.58 CPU1.AE1
  BOTTOM w0.114: C5808.1 64.04,116.16 64.14,116.05 64.14,115.83 64.23,115.73 64.38,115.73 67.03,118.38 81.27,118.38 84.51,115.14 84.51,109.15 84.28,108.92
DP2_DDI_TX_P0: length 53.5
  TOP w0.114: C5803.1 46.36,111.1 v2(46.36,110.54)
  BOTTOM w0.076: 82.03,108.46 82.03,108.45 82,108.42 82,107.51 82.07,107.44 82.07,106.84 81.88,106.65 81.88,106.38 81.91,106.3 81.91,106.02 81.88,105.94 81.88,105.73 81.95,105.57 CPU1.AC3
  BOTTOM w0.114: v2(46.36,110.54) 46.36,111.28 46.64,111.56 47.88,111.56 48.36,111.08 48.36,109.01 48.67,108.71 49.01,108.71 49.2,108.71 50.09,107.82 53.73,107.82 57.87,111.96 63.07,111.96 63.77,111.96 67.96,116.16 79.94,116.16 82.36,113.73 82.36,109.51 82.03,109.18 82.03,108.46
DP2_DDI_TX_P1: length 51.1
  TOP w0.114: C5801.1 50.17,111.38 50.17,111 49.36,110.19 49.1,110.19 v2(48.85,110.44)
  BOTTOM w0.076: 82.48,108.63 82.48,108.61 82.45,108.59 82.45,106.47 82.34,106.27 CPU1.AC2
  BOTTOM w0.114: v2(48.85,110.44) 49.09,110.2 49.41,110.2 49.69,109.93 49.69,109.24 50.31,108.61 53.53,108.61 57.58,112.66 63.36,112.66 67.6,116.9 80.31,116.9 83.06,114.15 83.06,109.35 82.48,108.77 82.48,108.63
DP2_DDI_TX_P2: length 37
  BOTTOM w0.076: 84.54,108.79 84.52,108.77 84.52,108.74 83.34,107.56 83.34,106.92 83.51,106.75 83.51,106.38 83.49,106.3 83.49,106.02 83.51,105.95 83.51,105.94 83.51,105.73 83.45,105.59 83.38,105.52 83.25,105.52 83.18,105.44 83.18,105.27 CPU1.AE3
  BOTTOM w0.114: C5805.1 62.25,116.67 62.53,116.67 62.65,116.8 62.65,117.32 62.78,117.45 64.98,117.45 66.38,118.85 81.61,118.85 84.99,115.47 84.99,109.24 84.54,108.79
DP2_DDI_TX_P3: length 32.7
  BOTTOM w0.076: 84.12,109.08 84.1,109.06 84.1,109.03 83,107.92 83,107.14 82.99,107.13 82.99,106.35 CPU1.AE2
  BOTTOM w0.114: C5807.1 64.37,115.39 67.13,118.15 81.17,118.15 84.28,115.04 84.28,109.24 84.12,109.08
DP2_DDI_TX_R_N0: length 0.6
  TOP w0.114: R5859.1 C5804.2
DP2_DDI_TX_R_N0_R: length 3.4
  TOP w0.114: R5859.2 47.37,113.77 48.26,113.77 49.2,114.71 49.2,114.99 49.3,115.09 U5802.7
DP2_DDI_TX_R_N1: length 0.6
  TOP w0.114: C5802.2 R5861.1
DP2_DDI_TX_R_N1_R: length 1.6
  TOP w0.114: U5802.10 50.5,114.9 50.39,114.79 50.39,114.33 R5861.2
DP2_DDI_TX_R_P0: length 0.6
  TOP w0.114: R5854.1 C5803.2
DP2_DDI_TX_R_P0_R: length 3.8
  TOP w0.114: R5854.2 46.84,114 48.17,114 48.97,114.8 48.97,114.99 48.9,115.06 U5802.6
DP2_DDI_TX_R_P1: length 0.6
  TOP w0.114: C5801.2 R5860.1
DP2_DDI_TX_R_P1_R: length 1.6
  TOP w0.114: U5802.9 50.1,114.9 50.16,114.84 50.16,114.35 R5860.2
DP2_DDI_TX_RE_C_N0: length 1.5
  TOP w0.114: R7178.2 24.92,103.73 24.76,103.9 24.38,103.9 24.28,103.99 U7101.10
DP2_DDI_TX_RE_C_N1: length 1.5
  TOP w0.114: U7101.13 24.43,105.19 24.54,105.08 25.13,105.08 R7180.2
DP2_DDI_TX_RE_C_N2: length 1.6
  TOP w0.114: U7101.16 24.43,106.39 24.52,106.31 24.78,106.31 R7182.2
DP2_DDI_TX_RE_C_N3: length 1.7
  TOP w0.114: R7184.2 25.27,108.43 24.43,107.59 U7101.19
DP2_DDI_TX_RE_C_P0: length 1.7
  TOP w0.114: R7177.2 25.33,103.01 24.66,103.67 24.35,103.67 24.27,103.59 U7101.9
DP2_DDI_TX_RE_C_P1: length 1.5
  TOP w0.114: U7101.12 24.43,104.79 24.5,104.86 24.99,104.86 R7179.2
DP2_DDI_TX_RE_C_P2: length 1.4
  TOP w0.114: U7101.15 24.43,105.99 24.52,106.08 25.32,106.08 R7181.2
DP2_DDI_TX_RE_C_P3: length 1.6
  TOP w0.114: U7101.18 24.36,107.19 24.81,107.65 R7183.2
DP2_DEMUX_OUT2_D0N: length 3.6
  TOP w0.114: U5802.39 51.3,120.77 51.22,120.85 51.22,123.32 R5841.2
DP2_DEMUX_OUT2_D0N_R: length 16.5
  TOP w0.114: R5832.1 47.98,111.66 47.88,111.76 v2(47.88,112.07) ; v2(51.95,122.94) 52,122.99 52,124.1 R5826.2
  L5 w0.102: v2(51.95,122.94) 51.7,122.7 51.7,118.35 49.08,115.72 49.08,114.53 46.87,112.32 46.87,112.19 46.99,112.07 v2(47.88,112.07)
DP2_DEMUX_OUT2_D0P: length 3.6
  TOP w0.114: U5802.40 50.9,120.77 50.99,120.85 50.99,123.33 R5840.2
DP2_DEMUX_OUT2_D0P_R: length 18.5
  TOP w0.114: v2(49.98,125.21) 49.88,125.11 R5827.2 ; R5833.1 45.55,111.66 45.72,111.84 v2(45.72,112.07)
  L5 w0.102: v2(49.98,125.21) 50.03,125.21 50.43,124.8 50.44,124.8 51.5,123.74 51.5,118.44 48.87,115.81 48.87,114.61 46.66,112.4 46.66,112.19 46.54,112.07 v2(45.72,112.07)
DP2_DEMUX_OUT2_D1N: length 3.4
  TOP w0.114: U5802.36 52.5,120.65 52.44,120.71 52.44,120.89 52.84,121.29 52.84,122.56 52.98,122.71 53.19,122.71 53.32,122.58 R5843.2
DP2_DEMUX_OUT2_D1N_R: length 14.9
  TOP w0.114: R5829.2 53.52,121.56 v2(53.44,121.64) ; v2(50.93,114.7) 51.11,114.51 51.11,113.61 51.18,113.54 51.18,112.02 R5839.1
  L5 w0.102: v2(53.44,121.64) 53.44,122.28 53.16,122.56 52.98,122.56 52.82,122.39 52.82,121.31 52.66,121.15 52.66,118.28 50.34,115.96 50.34,114.67 50.47,114.53 50.76,114.53 v2(50.93,114.7)
DP2_DEMUX_OUT2_D1P: length 3.6
  TOP w0.114: R5842.2 53.11,123.16 52.61,122.66 52.61,121.38 52.1,120.88 U5802.37
DP2_DEMUX_OUT2_D1P_R: length 15.7
  TOP w0.114: v2(52.53,123.29) 52.53,123.45 53.09,124 R5828.2 ; R5838.1 49.05,113.72 v2(48.97,113.79)
  L5 w0.102: v2(48.97,113.79) 49.47,113.79 50.13,114.45 50.13,116.04 52.45,118.37 52.45,121.24 52.62,121.4 52.62,122.48 52.89,122.75 52.89,122.93 v2(52.53,123.29)
DP2_HPD_CPU: length 283.1
  TOP w0.089: v2(25.34,23.04) 25.58,23.28 25.58,25.94 25.38,26.14 25.38,28.29 25.39,28.3 25.39,28.32 26.67,29.6 26.67,32.79 26.77,32.89 v2(26.77,33.91) ; v2(31.52,21.87) 32.22,22.56 32.22,22.88 32.64,23.3 32.64,23.72 35.05,26.14 35.05,28.02 38.87,31.84 50.49,31.84 53.13,34.48 53.13,35.66 52.44,36.35 52.44,40.53 53.32,41.41 53.32,42.14 52.71,42.74 52.71,50.46 56.94,54.69 110.88,54.69 126.02,69.83 126.02,97.01 124.85,98.18 124.85,99.89 v2(124.41,100.33) ; v2(47.59,114.62) 47.7,114.73 U5802.3
  L5 w0.089: v2(26.77,33.91) 25.69,32.82 22.18,32.82 21.67,33.34 21.67,46.33 22.52,47.18 22.52,50.14 22.92,50.54 22.92,52.1 23.85,53.03 23.85,54.29 25.51,55.95 25.86,55.95 26.46,56.55 26.46,56.95 30.58,61.07 30.58,66.01 32.33,67.76 32.33,68.57 32.87,69.11 37.04,69.11 38.74,70.81 38.74,71.71 40.36,73.33 40.36,75.86 41.32,76.81 42.01,77.5 42.01,77.65 42.01,79.68 41.36,80.32 41.36,96.38 43.61,98.62 43.61,105.27 43.26,105.61 43.26,107.01 44.22,107.96 44.22,112.03 45.51,113.32 45.89,113.32 45.89,113.32 46.81,113.32 47.59,114.1 v2(47.59,114.62)
  BOTTOM w0.089: Q401.5 127,100.99 126.5,100.48 v1(126.42,100.48) 125.56,100.48 R404.2 125.2,100.33 v2(124.41,100.33) ; v2(25.34,23.04) 25.34,22.31 26.01,21.65 31.3,21.65 31.52,21.87 v2(31.52,21.87)
DPEQ0_A1: length 3.8
  TOP w0.089: v2(24.69,105.56) 24.66,105.59 U7101.14
  BOTTOM w0.089: R7172.1 24.46,105.34 v2(24.69,105.56) 24.9,105.36 v1(24.9,104.9) 25.08,104.72 25.08,103.64 R7171.2
DPEQ1: length 3.6
  TOP w0.089: U7101.2 21,102.48 20.45,101.93 20.42,101.93 20.4,101.91 v1(20.4,101.91) 19.95,101.91 v2(19.82,101.78) R7147.2
  BOTTOM w0.089: R7170.1 19.92,101.78 v2(19.82,101.78)
EC_D_INHIB: length 33
  TOP w0.089: v2(51.79,71.76) 51.79,71.05 50.99,70.25 50.3,70.25 49.77,69.73 Q6408.B 49.77,68.95 C6405.1 50.19,66.96 R6414.1 50.8,66.3 D6403.A ; U2401.96 38.22,72.49 v2(37.96,72.23) ; v2(41.41,78.54) 41.33,78.46 R6404.1 v1(39.88,78.46)
  L3 w0.089: v2(37.96,72.23) 39.75,74.03 39.75,75.36 41.41,77.01 v2(41.41,78.54)
  BOTTOM w0.089: v2(37.96,72.23) 38.04,72.31 38.16,72.41 47.62,72.41 48.28,71.75 49.27,71.75 49.47,71.55 50.78,71.55 50.98,71.76 v2(51.79,71.76)
EDP_AUX_CON_N: length 3.8
  BOTTOM w0.114: C5521.2 215.92,55.32 216.72,55.32 217.58,56.19 218.27,56.19 218.4,56.05 LCD1.3
EDP_AUX_CON_P: length 3.8
  BOTTOM w0.114: C5526.2 215.91,55.55 216.62,55.55 217.48,56.41 218.26,56.41 218.4,56.55 LCD1.2
EDP_AUX_CPU_N: length 220.5
  L6 w0.102: v2(214.05,55.14) 214.07,55.16 218.38,55.16 222.15,58.93 222.15,59.1 222.15,64.51 220.91,65.75 212.44,65.75 210.7,64.01 201.07,64.01 199.37,62.31 190.78,62.31 189.02,60.54 184.66,60.54 181,64.21 181,66.62 178.78,68.84 178.05,68.84 177.49,69.39 176.68,69.39 176.18,69.9 173.34,69.9 172.55,70.69 164.25,70.69 163.33,71.6 160.84,71.6 160.25,72.19 132.25,72.19 129.39,75.04 129.39,89.06 128.93,89.52 128.93,92.67 128.45,93.16 128.45,104.04 127.1,105.39 127.1,109.65 126.02,110.73 126.02,111.81 124.43,113.4 124.43,115.04 122,117.47 122,119.11 118.14,122.97 118.14,123.81 117.35,124.6 115.43,124.6 114.45,125.58 111.29,125.58 v2(111.16,125.44)
  BOTTOM w0.076: CPU1.AH4 84.84,105.16 84.84,106.07 85.08,106.31 85.08,106.49 85.2,106.61 85.2,106.63
  BOTTOM w0.114: 109.38,124.64 110.66,124.64 111.16,125.15 v2(111.16,125.44) ; 109.38,124.64 v1(109.38,124.79) ; 109.38,124.64 108.69,124.64 106.38,122.33 93.48,122.33 87.14,115.99 87.14,108.68 85.2,106.74 85.2,106.63 ; v2(214.05,55.14) 214.09,55.14 214.19,55.05 C5521.1
EDP_AUX_CPU_P: length 220.4
  L6 w0.102: v2(111.76,125.15) 111.83,125.21 111.83,125.21 111.99,125.38 114.37,125.38 115.34,124.4 117.26,124.4 117.94,123.73 117.94,122.88 121.79,119.03 121.79,117.39 124.23,114.95 124.23,113.31 125.82,111.72 125.82,110.64 126.9,109.57 126.9,105.31 128.25,103.96 128.25,93.07 128.73,92.59 128.73,89.43 129.19,88.98 129.19,74.96 132.16,71.98 160.17,71.98 160.75,71.4 163.25,71.4 164.16,70.49 172.47,70.49 173.25,69.7 176.09,69.7 176.6,69.19 177.41,69.19 177.97,68.63 178.7,68.63 180.79,66.54 180.79,64.12 184.58,60.34 189.1,60.34 190.87,62.1 199.45,62.1 201.15,63.81 210.79,63.81 212.53,65.55 220.83,65.55 221.95,64.42 221.95,59.01 218.3,55.37 214.44,55.37 214.21,55.59 214.01,55.59 213.77,55.83 213.39,55.83 v2(213.29,55.73)
  BOTTOM w0.076: 85.43,106.62 85.43,106.59 85.4,106.55 85.4,106.55 85.28,106.43 85.28,106.43 85.26,106.42 85.26,106.24 85.02,106 85.02,105.63 CPU1.AH3
  BOTTOM w0.114: v2(213.29,55.73) 213.82,55.73 213.95,55.6 214.52,55.6 C5526.1 ; 87.37,110.31 87.37,115.9 93.58,122.1 106.47,122.1 108.78,124.41 110.75,124.41 111.51,125.17 111.74,125.17 111.76,125.15 v2(111.76,125.15) ; 87.37,110.31 87.37,108.59 85.43,106.64 85.43,106.62 ; 87.37,110.31 v1(87.53,110.31)
EDP_FHD_DET#: length 134.1
  TOP w0.089: v2(171.43,76.15) 171.68,76.15 v1(171.94,75.9) ; R2068.2 212.55,52.53 v2(212.65,52.63)
  L3 w0.089: v2(207.34,54.81) 207.11,55.05 197.41,55.05 197.37,55.09 197.1,55.09 196.69,55.49 196.69,55.65 196.45,55.9 196.18,55.9 194.98,57.1 194.98,58.29 194.55,58.72 183.64,58.72 179.25,63.11 179.25,65.44 173.62,71.07 173.62,73.25 171.79,75.08 171.79,75.79 v2(171.43,76.15)
  L5 w0.089: v2(207.34,54.81) 208.84,54.81 209.4,54.26 211.61,54.26 212.02,53.85 212.02,53.27 v2(212.65,52.63)
  BOTTOM w0.089: R5565.2 212.65,51.33 v2(212.65,52.63) ; CPU1.CL36 111.26,82.48 111.13,82.35 111.13,79.1 111.82,78.41 111.82,77.58 113.73,75.67 117.87,75.67 118.9,75.67 121.36,73.21 121.46,73.11 123.1,73.11 124.59,74.6 160.38,74.6 160.81,75.04 161,75.22 162.16,75.22 162.52,74.86 162.52,74.81 162.77,74.56 163.12,74.56 163.83,75.26 167.28,75.26 167.97,74.58 167.97,72.22 168.22,71.96 168.81,71.96 169.32,72.47 169.32,73.74 169.93,74.35 170.31,74.35 171.43,75.46 v2(171.43,76.15)
EDP_FHD_DET#_R: length 7.1
  BOTTOM w0.089: R5565.1 213.64,51.26 v1(213.64,51.39) 213.67,51.41 216.91,51.41 218.04,52.55 LCD1.10
EDP_HPD: length 214.5
  TOP w0.089: v2(154.03,33.81) 154.03,36.93 152.78,38.18 v2(152.77,38.18) ; v2(217.22,36.7) v1(218.04,36.7) 220.63,36.7 221.41,37.49 RN5502.4 221.54,38.03 221.41,38.15 RN5503.1
  L5 w0.089: v2(160.87,62.94) 161.2,63.27 164.42,63.27 164.98,62.71 167.3,62.71 168.68,61.33 168.68,60.03 170.97,57.74 170.97,56.24 173.17,54.04 v2(173.17,53.48)
  L6 w0.089: v2(217.22,36.7) 216.64,37.29 212.8,37.29 212.63,37.11 208.66,37.11 208.15,36.6 204.68,36.6 204.32,36.25 200.84,36.25 199.06,34.47 192.15,34.47 191.91,34.7 189.49,34.7 186.24,31.45 176.48,31.45 175.49,32.44 155.4,32.44 v2(154.03,33.81) ; v2(152.77,38.18) 153.4,37.55 155.67,37.55 157.03,38.91 167.54,38.91 169.39,40.77 169.95,40.77 172.7,43.52 172.7,47.19 173.38,47.87 173.38,53.27 v2(173.17,53.48) ; v2(160.87,62.94) 160.45,62.52 160.06,62.52 159.61,62.97 130.97,62.97 127.09,66.85 125.1,66.85 124.61,66.85 117.34,74.12 116.59,74.87 116.59,85.24 118.28,86.93 118.28,90.99 118.83,91.54 118.83,93.79 118.59,94.03 118.59,99.14 118.94,99.49 118.94,101.71 v2(117.96,102.69)
  BOTTOM w0.076: 114.02,102.34 113.44,102.34 113.39,102.32 113.38,102.32 113.08,102.32 113.07,102.32 113.02,102.34 112.57,102.34 112.18,102.74 CPU1.CM7
  BOTTOM w0.089: 114.02,102.34 117.61,102.34 v2(117.96,102.69)
EDP_HPD_CONN: length 4.3
  TOP w0.089: RN5503.8 220.96,39.52 220.48,39.04 AFTP5521.1 220.09,39.31 220.13,39.35 220.13,39.7 219.71,40.12 v2(219.71,40.67)
  BOTTOM w0.089: LCD1.33 219.33,41.05 v2(219.71,40.67)
EDP_RCOMP_CPU: length 16
  TOP w0.127: R401.2 83.74,92.46 v1(83.33,92.05) 83.59,91.8 v2(83.98,91.8) 83.87,91.7 FC8985.1
  L3 w0.127: v2(83.98,91.8) 83.98,96.52 86.57,99.11 86.57,102.9 v2(87.14,103.48)
  BOTTOM w0.127: v2(87.14,103.48) 87.21,103.48 CPU1.AM6
EDP_TX_CON_N0: length 3.8
  BOTTOM w0.114: C5525.2 215.68,53.53 216.78,53.53 217.93,54.69 218.27,54.69 218.4,54.55 LCD1.6
EDP_TX_CON_N1: length 3.8
  BOTTOM w0.114: LCD1.9 218.38,53.05 218.24,53.19 218.03,53.19 216.77,51.92 C5523.2
EDP_TX_CON_P0: length 4.4
  BOTTOM w0.114: C5524.2 215.83,54.45 216.2,54.45 216.32,54.32 216.32,53.89 216.45,53.76 216.68,53.76 217.84,54.91 218.26,54.91 218.4,55.05 LCD1.5
EDP_TX_CON_P1: length 4.8
  BOTTOM w0.114: C5522.2 215.65,52.89 215.77,53.02 216.21,53.02 216.33,52.89 216.33,52.28 216.46,52.15 216.68,52.15 217.94,53.41 218.29,53.41 218.42,53.55 LCD1.8
EDP_TX_CPU_N0: length 233.3
  L6 w0.102: v2(213.55,53.59) 213.74,53.77 220.78,53.77 223.45,56.44 223.45,64.09 221.2,66.33 221.03,66.33 212.2,66.33 210.71,64.85 200.71,64.85 198.78,62.92 190.43,62.92 188.64,61.13 184.9,61.13 181.58,64.45 181.58,66.86 179.02,69.42 178.35,69.42 177.79,69.98 176.93,69.98 176.41,70.49 173.57,70.49 172.74,71.32 164.77,71.32 163.9,72.19 161.11,72.19 160.49,72.81 159.1,72.81 158.15,73.76 141.15,73.76 140.16,72.77 132.49,72.77 129.97,75.29 129.97,89.3 129.52,89.76 129.52,93.34 129.04,93.82 129.04,104.85 128.67,105.21 128.67,108.91 127.46,110.12 127.46,111.76 125.3,113.92 125.3,115.08 122.74,117.64 122.74,119.32 118.72,123.34 118.72,124.05 117.58,125.2 115.81,125.2 114.85,126.16 111.42,126.16 110.21,127.36 110.21,127.91 110.37,128.06 110.37,128.83 110.12,129.07 109.73,129.07 109.66,129.01 109.56,128.9 v2(109.26,128.89)
  BOTTOM w0.076: 84.32,107.34 84.32,107.32 84.35,107.29 84.35,107.04 84.29,106.88 84.14,106.73 84.14,106.35 84.15,106.32 84.17,106.27 84.17,106.05 84.14,105.97 84.14,105.67 84.16,105.66 84.2,105.55 84.2,105.16 84.28,104.96 CPU1.AG4
  BOTTOM w0.114: v2(109.26,128.89) 109.26,128.89 109.27,128.89 109.27,128.62 107.97,127.32 ; 84.32,107.34 84.32,107.51 85.73,108.91 85.73,116.59 92.87,123.72 105.72,123.72 107.65,125.65 107.65,127 107.97,127.32 ; C5525.1 213.64,53.5 v2(213.55,53.59) ; v1(107.85,127.43) 107.97,127.32
EDP_TX_CPU_N1: length 232.7
  L6 w0.102: v2(214.01,51.98) 214.46,51.98 215.65,53.16 221.17,53.16 224.06,56.05 224.06,64.42 221.5,66.98 221.33,66.98 221.33,66.98 211.91,66.98 210.56,65.63 200.53,65.63 198.47,63.58 190.25,63.58 188.41,61.74 185.12,61.74 182.43,64.43 182.43,66.84 179.26,70 178.59,70 178.03,70.56 177.17,70.56 176.65,71.08 173.82,71.08 172.96,71.93 165.23,71.93 164.37,72.8 161.43,72.8 159.88,74.35 132.27,74.35 130.58,76.03 130.58,89.52 130.13,89.98 130.13,93.96 129.64,94.44 129.64,101.34 130.15,101.85 130.15,105.08 129.29,105.94 129.29,109.13 128.04,110.37 128.04,112.15 126.14,114.06 126.14,115.23 123.38,117.98 123.38,119.51 121.08,121.81 121.08,122.54 117.85,125.78 116.51,125.78 115.42,126.87 112.64,126.87 111.73,127.78 111.13,127.78 111.07,127.71 110.97,127.59 v2(110.67,127.55)
  BOTTOM w0.076: CPU1.AG2 84.58,106.08 84.9,106.4 84.9,107 85.91,108.02 85.95,108.02 85.96,108.03
  BOTTOM w0.114: 110.01,126.01 109.34,126.01 106.13,122.8 93.25,122.8 86.67,116.22 86.67,108.74 85.96,108.03 ; 110.01,126.01 112.01,126.01 112.42,126.42 112.42,127.1 111.74,127.79 111.2,127.79 110.97,127.55 v2(110.67,127.55) ; 110.01,126.01 v1(110.01,125.86) ; C5523.1 214.71,51.94 214.04,51.94 v2(214.01,51.98)
EDP_TX_CPU_P0: length 232.8
  L6 w0.102: v2(109.72,128.46) 109.71,128.76 109.81,128.87 110.04,128.87 110.16,128.74 110.16,128.14 110.01,127.99 110.01,127.28 111.33,125.96 114.76,125.96 115.73,124.99 117.49,124.99 118.52,123.97 118.52,123.26 122.54,119.24 122.54,117.56 125.1,115 125.1,113.84 127.26,111.68 127.26,110.03 128.47,108.82 128.47,105.13 128.83,104.77 128.83,93.74 129.31,93.26 129.31,89.68 129.77,89.22 129.77,75.2 132.41,72.57 140.24,72.57 141.24,73.56 158.07,73.56 159.02,72.61 160.41,72.61 161.02,71.99 163.82,71.99 164.69,71.12 172.66,71.12 173.49,70.29 176.33,70.29 176.84,69.78 177.71,69.78 178.26,69.22 178.94,69.22 181.38,66.78 181.38,64.37 184.82,60.93 188.72,60.93 190.51,62.71 198.86,62.71 200.79,64.64 210.8,64.64 212.28,66.13 221.11,66.13 223.24,64 223.24,56.52 220.7,53.98 214.2,53.98 214.1,54.08 214.1,54.26 214,54.36 213.78,54.36 v2(213.64,54.22)
  BOTTOM w0.076: 84.55,107.34 84.55,107.32 84.53,107.29 84.53,106.86 84.32,106.65 84.32,106.38 84.35,106.3 84.35,106.02 84.32,105.94 84.32,105.73 84.37,105.61 84.38,105.6 84.38,105.22 84.42,105.18 CPU1.AG3
  BOTTOM w0.114: v2(213.64,54.22) 213.64,54.11 214.03,53.73 214.15,53.73 214.28,53.85 214.28,54.36 214.4,54.49 214.58,54.49 214.73,54.33 C5524.1 ; v1(108.03,125.76) 107.88,125.76 ; 107.88,125.76 107.88,126.91 109.43,128.46 109.72,128.46 v2(109.72,128.46) ; 107.88,125.76 107.88,125.56 105.82,123.5 92.96,123.5 85.96,116.49 85.96,108.81 84.55,107.41 84.55,107.34
