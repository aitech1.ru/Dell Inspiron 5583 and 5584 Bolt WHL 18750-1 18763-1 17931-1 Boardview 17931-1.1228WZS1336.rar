# Allegro board 17931-1.1228WZS1336.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
AFTE14P-75
  round 0.356 smd: 1(0,0)
ARES2H16
  rect 0.457x0.635 smd: 1(-0.335,-0.44) 2(0.335,-0.44) 3(0.335,0.44) 4(-0.335,0.44)
ARES2H18
  rect 0.457x0.635 smd: 1(-0.335,-0.44) 2(0.335,-0.44) 3(0.335,0.44) 4(-0.335,0.44)
ARES8-CN24-MUH20
  rect 0.457x0.61 smd: 1(-0.838,-0.445) 4(0.838,-0.445) 5(0.838,0.445) 8(-0.838,0.445)
  rect 0.305x0.61 smd: 2(-0.25,-0.445) 3(0.25,-0.445) 6(0.25,0.445) 7(-0.25,0.445)
ARES8-CN24-UH20
  rect 0.457x0.61 smd: 1(-0.838,-0.445) 4(0.838,-0.445) 5(0.838,0.445) 8(-0.838,0.445)
  rect 0.305x0.61 smd: 2(-0.25,-0.445) 3(0.25,-0.445) 6(0.25,0.445) 7(-0.25,0.445)
ARES8-CN24H20
  rect 0.457x0.559 smd: 1(-0.838,-0.483) 4(0.838,-0.483) 5(0.838,0.483) 8(-0.838,0.483)
  rect 0.305x0.559 smd: 2(-0.25,-0.483) 3(0.25,-0.483) 6(0.25,0.483) 7(-0.25,0.483)
ARES8-CN24H22
  rect 0.457x0.559 smd: 1(-0.838,-0.483) 4(0.838,-0.483) 5(0.838,0.483) 8(-0.838,0.483)
  rect 0.305x0.559 smd: 2(-0.25,-0.483) 3(0.25,-0.483) 6(0.25,0.483) 7(-0.25,0.483)
BGA170D1214H48
  round 0.406 smd: A1(-5.2,6.4) A2(-4.4,6.4) A3(-3.6,6.4) A12(3.6,6.4) A13(4.4,6.4) A14(5.2,6.4) B1(-5.2,5.6) B2(-4.4,5.6) B3(-3.6,5.6) B12(3.6,5.6) B13(4.4,5.6) B14(5.2,5.6) C1(-5.2,4.8) C2(-4.4,4.8) C3(-3.6,4.8) C12(3.6,4.8) C13(4.4,4.8) C14(5.2,4.8) R1(-5.2,-4.8) R2(-4.4,-4.8) R3(-3.6,-4.8) R12(3.6,-4.8) R13(4.4,-4.8) R14(5.2,-4.8) T1(-5.2,-5.6) T2(-4.4,-5.6) T3(-3.6,-5.6) T12(3.6,-5.6) T13(4.4,-5.6) T14(5.2,-5.6) U1(-5.2,-6.4) U2(-4.4,-6.4) U3(-3.6,-6.4) U12(3.6,-6.4) U13(4.4,-6.4) U14(5.2,-6.4)
  round 0.356 smd: A4(-2.8,6.4) A5(-2,6.4) A10(2,6.4) A11(2.8,6.4) B4(-2.8,5.6) B5(-2,5.6) B10(2,5.6) B11(2.8,5.6) C4(-2.8,4.8) C5(-2,4.8) C10(2,4.8) C11(2.8,4.8) D1(-5.2,4) D2(-4.4,4) D3(-3.6,4) D4(-2.8,4) D5(-2,4) D10(2,4) D11(2.8,4) D12(3.6,4) D13(4.4,4) D14(5.2,4) E1(-5.2,3.2) E2(-4.4,3.2) E3(-3.6,3.2) E4(-2.8,3.2) E5(-2,3.2) E10(2,3.2) E11(2.8,3.2) E12(3.6,3.2) E13(4.4,3.2) E14(5.2,3.2) F1(-5.2,2.4) F2(-4.4,2.4) F3(-3.6,2.4) F4(-2.8,2.4) F5(-2,2.4) F10(2,2.4) F11(2.8,2.4) F12(3.6,2.4) F13(4.4,2.4) F14(5.2,2.4) G1(-5.2,1.6) G2(-4.4,1.6) G3(-3.6,1.6) G4(-2.8,1.6) G5(-2,1.6) G10(2,1.6) G11(2.8,1.6) G12(3.6,1.6) G13(4.4,1.6) G14(5.2,1.6) H1(-5.2,0.8) H2(-4.4,0.8) H3(-3.6,0.8) H4(-2.8,0.8) H5(-2,0.8) H10(2,0.8) H11(2.8,0.8) H12(3.6,0.8) H13(4.4,0.8) H14(5.2,0.8) J1(-5.2,0) J2(-4.4,0) J3(-3.6,0) J4(-2.8,0) J5(-2,0) J10(2,0) J11(2.8,0) J12(3.6,0) J13(4.4,0) J14(5.2,0) K1(-5.2,-0.8) K2(-4.4,-0.8) K3(-3.6,-0.8) K4(-2.8,-0.8) K5(-2,-0.8) K10(2,-0.8) K11(2.8,-0.8) K12(3.6,-0.8) K13(4.4,-0.8) K14(5.2,-0.8) L1(-5.2,-1.6) L2(-4.4,-1.6) L3(-3.6,-1.6) L4(-2.8,-1.6) L5(-2,-1.6) L10(2,-1.6) L11(2.8,-1.6) L12(3.6,-1.6) L13(4.4,-1.6) L14(5.2,-1.6) M1(-5.2,-2.4) M2(-4.4,-2.4) M3(-3.6,-2.4) M4(-2.8,-2.4) M5(-2,-2.4) M10(2,-2.4) M11(2.8,-2.4) M12(3.6,-2.4) M13(4.4,-2.4) M14(5.2,-2.4) N1(-5.2,-3.2) N2(-4.4,-3.2) N3(-3.6,-3.2) N4(-2.8,-3.2) N5(-2,-3.2) N10(2,-3.2) N11(2.8,-3.2) N12(3.6,-3.2) N13(4.4,-3.2) N14(5.2,-3.2) P1(-5.2,-4) P2(-4.4,-4) P3(-3.6,-4) P4(-2.8,-4) P5(-2,-4) P10(2,-4) P11(2.8,-4) P12(3.6,-4) P13(4.4,-4) P14(5.2,-4) R4(-2.8,-4.8) R5(-2,-4.8) R10(2,-4.8) R11(2.8,-4.8) T4(-2.8,-5.6) T5(-2,-5.6) T10(2,-5.6) T11(2.8,-5.6) U4(-2.8,-6.4) U5(-2,-6.4) U10(2,-6.4) U11(2.8,-6.4)
BGA595M23H83
  round 0.432 smd: A2(-9.9,10.7) A3(-9.1,10.7) A25(9.1,10.7) A26(9.9,10.7) AE1(-10.7,-9.1) AE2(-9.9,-9.1) AE3(-9.1,-9.1) AE25(9.1,-9.1) AE26(9.9,-9.1) AE27(10.7,-9.1) AF1(-10.7,-9.9) AF2(-9.9,-9.9) AF3(-9.1,-9.9) AF25(9.1,-9.9) AF26(9.9,-9.9) AF27(10.7,-9.9) AG2(-9.9,-10.7) AG3(-9.1,-10.7) AG25(9.1,-10.7) AG26(9.9,-10.7) B1(-10.7,9.9) B2(-9.9,9.9) B3(-9.1,9.9) B25(9.1,9.9) B26(9.9,9.9) B27(10.7,9.9) C1(-10.7,9.1) C2(-9.9,9.1) C3(-9.1,9.1) C25(9.1,9.1) C26(9.9,9.1) C27(10.7,9.1)
  round 0.381 smd: A4(-8.3,10.7) A6(-6.6,10.7) A7(-5.8,10.7) A9(-4.12,10.7) A10(-3.32,10.7) A12(-1.64,10.7) A13(-0.84,10.7) A15(0.84,10.7) A16(1.64,10.7) A18(3.32,10.7) A19(4.12,10.7) A21(5.8,10.7) A22(6.6,10.7) A24(8.3,10.7) AA1(-10.7,-5.8) AA2(-9.9,-5.8) AA3(-9.1,-5.8) AA4(-8.3,-5.8) AA5(-7.5,-5.8) AA6(-6.66,-5.8) AA7(-5.8,-5.8) AA8(-4.96,-5.8) AA9(-4.12,-5.86) AA10(-3.32,-5.86) AA12(-1.64,-5.86) AA13(-0.84,-5.86) AA14(0,-5.86) AA15(0.84,-5.86) AA16(1.64,-5.86) AA18(3.32,-5.86) AA19(4.12,-5.86) AA20(4.96,-5.8) AA21(5.8,-5.8) AA22(6.66,-5.8) AA23(7.5,-5.8) AA24(8.3,-5.8) AA25(9.1,-5.8) AA26(9.9,-5.8) AA27(10.7,-5.8) AB1(-10.7,-6.6) AB2(-9.9,-6.6) AB3(-9.1,-6.6) AB4(-8.3,-6.6) AB5(-7.5,-6.6) AB6(-6.6,-6.6) AB7(-5.8,-6.66) AB8(-4.96,-6.66) AB9(-4.12,-6.66) AB10(-3.32,-6.66) AB11(-2.48,-6.66) AB12(-1.64,-6.66) AB13(-0.84,-6.66) AB14(0,-6.66) AB15(0.84,-6.66) AB16(1.64,-6.66) AB17(2.48,-6.66) AB18(3.32,-6.66) AB19(4.12,-6.66) AB20(4.96,-6.66) AB21(5.8,-6.66) AB22(6.6,-6.6) AB23(7.5,-6.6) AB24(8.3,-6.6) AB25(9.1,-6.6) AB26(9.9,-6.6) AB27(10.7,-6.6) AC2(-9.9,-7.45) AC3(-9.1,-7.45) AC4(-8.3,-7.45) AC5(-7.45,-7.45) AC6(-6.6,-7.5) AC7(-5.8,-7.5) AC8(-4.96,-7.5) AC9(-4.12,-7.5) AC10(-3.32,-7.5) AC11(-2.48,-7.5) AC12(-1.64,-7.5) AC13(-0.84,-7.5) AC14(0,-7.5) AC15(0.84,-7.5) AC16(1.64,-7.5) AC17(2.48,-7.5) AC18(3.32,-7.5) AC19(4.12,-7.5) AC20(4.96,-7.5) AC21(5.8,-7.5) AC22(6.6,-7.5) AC23(7.45,-7.45) AC24(8.3,-7.45) AC25(9.1,-7.45) AC26(9.9,-7.45) AD1(-10.7,-8.3) AD2(-9.9,-8.3) AD3(-9.1,-8.3) AD4(-8.3,-8.3) AD5(-7.45,-8.3) AD6(-6.6,-8.3) AD7(-5.8,-8.3) AD8(-4.96,-8.3) AD9(-4.12,-8.3) AD10(-3.32,-8.3) AD11(-2.48,-8.3) AD12(-1.64,-8.3) AD13(-0.84,-8.3) AD14(0,-8.3) AD15(0.84,-8.3) AD16(1.64,-8.3) AD17(2.48,-8.3) AD18(3.32,-8.3) AD19(4.12,-8.3) AD20(4.96,-8.3) AD21(5.8,-8.3) AD22(6.6,-8.3) AD23(7.45,-8.3) AD24(8.3,-8.3) AD25(9.1,-8.3) AD26(9.9,-8.3) AD27(10.7,-8.3) AE4(-8.3,-9.1) AE5(-7.45,-9.1) AE6(-6.6,-9.1) AE7(-5.8,-9.1) AE8(-4.96,-9.1) AE9(-4.12,-9.1) AE10(-3.32,-9.1) AE11(-2.48,-9.1) AE12(-1.64,-9.1) AE13(-0.84,-9.1) AE14(0,-9.1) AE15(0.84,-9.1) AE16(1.64,-9.1) AE17(2.48,-9.1) AE18(3.32,-9.1) AE19(4.12,-9.1) AE20(4.96,-9.1) AE21(5.8,-9.1) AE22(6.6,-9.1) AE23(7.45,-9.1) AE24(8.3,-9.1) AF4(-8.3,-9.9) AF5(-7.45,-9.9) AF6(-6.6,-9.9) AF7(-5.8,-9.9) AF8(-4.96,-9.9) AF9(-4.12,-9.9) AF10(-3.32,-9.9) AF11(-2.48,-9.9) AF12(-1.64,-9.9) AF13(-0.84,-9.9) AF14(0,-9.9) AF15(0.84,-9.9) AF16(1.64,-9.9) AF17(2.48,-9.9) AF18(3.32,-9.9) AF19(4.12,-9.9) AF20(4.96,-9.9) AF21(5.8,-9.9) AF22(6.6,-9.9) AF23(7.45,-9.9) AF24(8.3,-9.9) AG4(-8.3,-10.7) AG6(-6.6,-10.7) AG7(-5.8,-10.7) AG9(-4.12,-10.7) AG10(-3.32,-10.7) AG12(-1.64,-10.7) AG13(-0.84,-10.7) AG15(0.84,-10.7) AG16(1.64,-10.7) AG18(3.32,-10.7) AG19(4.12,-10.7) AG21(5.8,-10.7) AG22(6.6,-10.7) AG24(8.3,-10.7) B4(-8.3,9.9) B5(-7.45,9.9) B6(-6.6,9.9) B7(-5.8,9.9) B8(-4.96,9.9) B9(-4.12,9.9) B10(-3.32,9.9) B11(-2.48,9.9) B12(-1.64,9.9) B13(-0.84,9.9) B14(0,9.9) B15(0.84,9.9) B16(1.64,9.9) B17(2.48,9.9) B18(3.32,9.9) B19(4.12,9.9) B20(4.96,9.9) B21(5.8,9.9) B22(6.6,9.9) B23(7.45,9.9) B24(8.3,9.9) C4(-8.3,9.1) C5(-7.45,9.1) C6(-6.6,9.1) C7(-5.8,9.1) C8(-4.96,9.1) C9(-4.12,9.1) C10(-3.32,9.1) C11(-2.48,9.1) C12(-1.64,9.1) C13(-0.84,9.1) C14(0,9.1) C15(0.84,9.1) C16(1.64,9.1) C17(2.48,9.1) C18(3.32,9.1) C19(4.12,9.1) C20(4.96,9.1) C21(5.8,9.1) C22(6.6,9.1) C23(7.45,9.1) C24(8.3,9.1) D1(-10.7,8.3) D2(-9.9,8.3) D3(-9.1,8.3) D4(-8.3,8.3) D5(-7.45,8.3) D6(-6.6,8.3) D7(-5.8,8.3) D8(-4.96,8.3) D9(-4.12,8.3) D10(-3.32,8.3) D11(-2.48,8.3) D12(-1.64,8.3) D13(-0.84,8.3) D14(0,8.3) D15(0.84,8.3) D16(1.64,8.3) D17(2.48,8.3) D18(3.32,8.3) D19(4.12,8.3) D20(4.96,8.3) D21(5.8,8.3) D22(6.6,8.3) D23(7.45,8.3) D24(8.3,8.3) D25(9.1,8.3) D26(9.9,8.3) D27(10.7,8.3) E2(-9.9,7.45) E3(-9.1,7.45) E4(-8.3,7.45) E5(-7.45,7.45) E6(-6.6,7.5) E7(-5.8,7.5) E8(-4.96,7.5) E9(-4.12,7.5) E10(-3.32,7.5) E11(-2.48,7.5) E12(-1.64,7.5) E13(-0.84,7.5) E14(0,7.5) E15(0.84,7.5) E16(1.64,7.5) E17(2.48,7.5) E18(3.32,7.5) E19(4.12,7.5) E20(4.96,7.5) E21(5.8,7.5) E22(6.6,7.5) E23(7.45,7.45) E24(8.3,7.45) E25(9.1,7.45) E26(9.9,7.45) F1(-10.7,6.6) F2(-9.9,6.6) F3(-9.1,6.6) F4(-8.3,6.6) F5(-7.5,6.6) F6(-6.6,6.6) F7(-5.8,6.66) F8(-4.96,6.66) F9(-4.12,6.66) F10(-3.32,6.66) F11(-2.48,6.66) F12(-1.64,6.66) F13(-0.84,6.66) F14(0,6.66) F15(0.84,6.66) F16(1.64,6.66) F17(2.48,6.66) F18(3.32,6.66) F19(4.12,6.66) F20(4.96,6.66) F21(5.8,6.66) F22(6.6,6.6) F23(7.5,6.6) F24(8.3,6.6) F25(9.1,6.6) F26(9.9,6.6) F27(10.7,6.6) G1(-10.7,5.8) G2(-9.9,5.8) G3(-9.1,5.8) G4(-8.3,5.8) G5(-7.5,5.8) G6(-6.66,5.8) G7(-5.8,5.8) G8(-4.96,5.8) G9(-4.12,5.86) G10(-3.32,5.86) G12(-1.64,5.86) G13(-0.84,5.86) G14(0,5.86) G15(0.84,5.86) G16(1.64,5.86) G18(3.32,5.86) G19(4.12,5.86) G20(4.96,5.8) G21(5.8,5.8) G22(6.66,5.8) G23(7.5,5.8) G24(8.3,5.8) G25(9.1,5.8) G26(9.9,5.8) G27(10.7,5.8) H2(-9.9,4.96) H3(-9.1,4.96) H4(-8.3,4.96) H5(-7.5,4.96) H6(-6.66,4.96) H22(6.66,4.96) H23(7.5,4.96) H24(8.3,4.96) H25(9.1,4.96) H26(9.9,4.96) J1(-10.7,4.12) J2(-9.9,4.12) J3(-9.1,4.12) J4(-8.3,4.12) J5(-7.5,4.12) J6(-6.66,4.12) J7(-5.86,4.12) J21(5.86,4.12) J22(6.66,4.12) J23(7.5,4.12) J24(8.3,4.12) J25(9.1,4.12) J26(9.9,4.12) J27(10.7,4.12) K1(-10.7,3.32) K2(-9.9,3.32) K3(-9.1,3.32) K4(-8.3,3.32) K5(-7.5,3.32) K6(-6.66,3.32) K7(-5.86,3.32) K21(5.86,3.32) K22(6.66,3.32) K23(7.5,3.32) K24(8.3,3.32) K25(9.1,3.32) K26(9.9,3.32) K27(10.7,3.32) L2(-9.9,2.48) L3(-9.1,2.48) L4(-8.3,2.48) L5(-7.5,2.48) L6(-6.66,2.48) L22(6.66,2.48) L23(7.5,2.48) L24(8.3,2.48) L25(9.1,2.48) L26(9.9,2.48) M1(-10.7,1.64) M2(-9.9,1.64) M3(-9.1,1.64) M4(-8.3,1.64) M5(-7.5,1.64) M6(-6.66,1.64) M7(-5.86,1.64) M21(5.86,1.64) M22(6.66,1.64) M23(7.5,1.64) M24(8.3,1.64) M25(9.1,1.64) M26(9.9,1.64) M27(10.7,1.64) N1(-10.7,0.84) N2(-9.9,0.84) N3(-9.1,0.84) N4(-8.3,0.84) N5(-7.5,0.84) N6(-6.66,0.84) N7(-5.86,0.84) N21(5.86,0.84) N22(6.66,0.84) N23(7.5,0.84) N24(8.3,0.84) N25(9.1,0.84) N26(9.9,0.84) N27(10.7,0.84) P2(-9.9,0) P3(-9.1,0) P4(-8.3,0) P5(-7.5,0) P6(-6.66,0) P22(6.66,0) P23(7.5,0) P24(8.3,0) P25(9.1,0) P26(9.9,0) R1(-10.7,-0.84) R2(-9.9,-0.84) R3(-9.1,-0.84) R4(-8.3,-0.84) R5(-7.5,-0.84) R6(-6.66,-0.84) R7(-5.86,-0.84) R21(5.86,-0.84) R22(6.66,-0.84) R23(7.5,-0.84) R24(8.3,-0.84) R25(9.1,-0.84) R26(9.9,-0.84) R27(10.7,-0.84) T1(-10.7,-1.64) T2(-9.9,-1.64) T3(-9.1,-1.64) T4(-8.3,-1.64) T5(-7.5,-1.64) T6(-6.66,-1.64) T7(-5.86,-1.64) T21(5.86,-1.64) T22(6.66,-1.64) T23(7.5,-1.64) T24(8.3,-1.64) T25(9.1,-1.64) T26(9.9,-1.64) T27(10.7,-1.64) U2(-9.9,-2.48) U3(-9.1,-2.48) U4(-8.3,-2.48) U5(-7.5,-2.48) U6(-6.66,-2.48) U22(6.66,-2.48) U23(7.5,-2.48) U24(8.3,-2.48) U25(9.1,-2.48) U26(9.9,-2.48) V1(-10.7,-3.32) V2(-9.9,-3.32) V3(-9.1,-3.32) V4(-8.3,-3.32) V5(-7.5,-3.32) V6(-6.66,-3.32) V7(-5.86,-3.32) V21(5.86,-3.32) V22(6.66,-3.32) V23(7.5,-3.32) V24(8.3,-3.32) V25(9.1,-3.32) V26(9.9,-3.32) V27(10.7,-3.32) W1(-10.7,-4.12) W2(-9.9,-4.12) W3(-9.1,-4.12) W4(-8.3,-4.12) W5(-7.5,-4.12) W6(-6.66,-4.12) W7(-5.86,-4.12) W21(5.86,-4.12) W22(6.66,-4.12) W23(7.5,-4.12) W24(8.3,-4.12) W25(9.1,-4.12) W26(9.9,-4.12) W27(10.7,-4.12) Y2(-9.9,-4.96) Y3(-9.1,-4.96) Y4(-8.3,-4.96) Y5(-7.5,-4.96) Y6(-6.66,-4.96) Y22(6.66,-4.96) Y23(7.5,-4.96) Y24(8.3,-4.96) Y25(9.1,-4.96) Y26(9.9,-4.96)
  round 0.457 smd: K10(-4,4) K11(-3,4) K12(-2,4) K13(-1,4) K14(0,4) K15(1,4) K16(2,4) K17(3,4) K18(4,4) L10(-4,3) L11(-3,3) L12(-2,3) L13(-1,3) L14(0,3) L15(1,3) L16(2,3) L17(3,3) L18(4,3) M10(-4,2) M11(-3,2) M12(-2,2) M13(-1,2) M14(0,2) M15(1,2) M16(2,2) M17(3,2) M18(4,2) N10(-4,1) N11(-3,1) N12(-2,1) N13(-1,1) N14(0,1) N15(1,1) N16(2,1) N17(3,1) N18(4,1) P10(-4,0) P11(-3,0) P12(-2,0) P13(-1,0) P14(0,0) P15(1,0) P16(2,0) P17(3,0) P18(4,0) R10(-4,-1) R11(-3,-1) R12(-2,-1) R13(-1,-1) R14(0,-1) R15(1,-1) R16(2,-1) R17(3,-1) R18(4,-1) T10(-4,-2) T11(-3,-2) T12(-2,-2) T13(-1,-2) T14(0,-2) T15(1,-2) T16(2,-2) T17(3,-2) T18(4,-2) U10(-4,-3) U11(-3,-3) U12(-2,-3) U13(-1,-3) U14(0,-3) U15(1,-3) U16(2,-3) U17(3,-3) U18(4,-3) V10(-4,-4) V11(-3,-4) V12(-2,-4) V13(-1,-4) V14(0,-4) V15(1,-4) V16(2,-4) V17(3,-4) V18(4,-4)
BGA1528M2446-1H52
  round 0.356 smd: A3(-10.396,22.315) A36(10.855,22.315) B2(-10.855,21.855) B37(11.315,21.855) C1(-11.315,21.396) CP1(-11.315,-21.855) CP37(11.315,-21.855) CR2(-10.855,-22.315) CR36(10.855,-22.315)
  round 0.33 smd: A4(-9.746,22.315) A35(10.205,22.315) B3(-10.227,21.687) B36(10.687,21.687) C2(-10.687,21.227) C37(11.315,21.205) CN1(-11.315,-21.205) CN37(11.315,-21.205) CP2(-10.687,-21.687) CP36(10.687,-21.687) CR3(-10.205,-22.315) CR35(10.205,-22.315) D1(-11.315,20.746)
  round 0.305 smd: A5(-9.096,22.292) A6(-8.232,22.315) A32(8.228,22.315) A34(9.555,22.315) AA4(-9.365,10.421) AA9(-6.21,10.624) AA24(3.679,10.481) AA26(4.606,10.481) AA34(9.365,10.719) AB3(-10.334,9.763) AB4(-9.325,9.763) AB5(-8.617,10.162) AB6(-7.967,10.162) AB7(-7.317,10.162) AB8(-6.668,10.162) AB9(-6.21,9.7) AB10(-5.753,10.162) AB25(4.142,10.025) AB27(5.069,10.025) AB28(5.719,10.025) AB29(6.369,10.025) AB30(7.019,10.025) AB31(7.669,10.025) AB32(8.32,10.025) AB33(9.04,10.068) AB34(9.69,10.068) AC4(-9.365,9.106) AC5(-8.617,9.238) AC6(-7.967,9.238) AC7(-7.317,9.238) AC8(-6.668,9.238) AC10(-5.753,9.238) AC24(3.679,9.57) AC25(4.142,9.114) AC26(4.606,9.57) AC27(5.069,9.114) AC28(5.719,9.114) AC29(6.369,9.114) AC30(7.019,9.114) AC31(7.669,9.114) AC32(8.32,9.114) AC34(9.365,9.417) AD4(-9.69,8.543) AD9(-6.21,8.776) AD24(3.679,8.658) AD26(4.606,8.658) AD33(9.04,8.809) AD35(10.245,8.809) AE4(-9.365,7.98) AE5(-8.617,8.314) AE6(-7.967,8.314) AE7(-7.317,8.314) AE8(-6.668,8.314) AE9(-6.21,7.852) AE10(-5.753,8.314) AE24(3.679,7.747) AE25(4.142,8.203) AE26(4.606,7.747) AE27(5.069,8.203) AE28(5.719,8.203) AE29(6.369,8.203) AE30(7.019,8.203) AE31(7.669,8.203) AE32(8.32,8.203) AE34(9.365,8.202) AF3(-10.334,7.322) AF4(-9.325,7.322) AF5(-8.617,7.39) AF6(-7.967,7.39) AF7(-7.317,7.39) AF8(-6.668,7.39) AF10(-5.753,7.39) AF25(4.142,7.291) AF27(5.069,7.291) AF28(5.719,7.291) AF29(6.369,7.291) AF30(7.019,7.291) AF31(7.669,7.291) AF32(8.32,7.291) AF33(9.04,7.551) AF34(9.69,7.551) AG4(-9.365,6.665) AG5(-8.617,6.467) AG6(-7.967,6.467) AG7(-7.317,6.467) AG8(-6.668,6.467) AG9(-6.21,6.929) AG10(-5.753,6.467) AG24(3.679,6.835) AG26(4.606,6.835) AG34(9.365,6.9) AH4(-9.69,6.102) AH9(-6.21,6.005) AH24(3.679,5.924) AH25(4.142,6.38) AH26(4.606,5.924) AH27(5.069,6.38) AH28(5.719,6.38) AH29(6.369,6.38) AH30(7.019,6.38) AH31(7.669,6.38) AH32(8.32,6.38) AH33(9.04,6.293) AH35(10.245,6.293) AJ4(-9.365,5.539) AJ5(-8.617,5.543) AJ6(-7.967,5.543) AJ7(-7.317,5.543) AJ8(-6.668,5.543) AJ10(-5.753,5.543) AJ25(4.142,5.468) AJ27(5.069,5.468) AJ28(5.719,5.468) AJ29(6.369,5.468) AJ30(7.019,5.468) AJ31(7.669,5.468) AJ32(8.32,5.468) AJ34(9.365,5.685) AK3(-10.334,4.882) AK4(-9.325,4.882) AK9(-6.21,5.081) AK24(3.679,5.013) AK26(4.606,5.013) AK33(9.04,5.034) AK34(9.69,5.034) AL4(-9.365,4.224) AL5(-8.617,4.619) AL6(-7.967,4.619) AL7(-7.317,4.619) AL8(-6.668,4.619) AL9(-6.21,4.157) AL10(-5.753,4.619) AL24(3.679,4.101) AL25(4.142,4.557) AL26(4.606,4.101) AL27(5.069,4.557) AL28(5.719,4.557) AL29(6.369,4.557) AL30(7.019,4.557) AL31(7.669,4.557) AL32(8.32,4.557) AL34(9.365,4.383) AM4(-9.69,3.661) AM5(-8.617,3.695) AM6(-7.967,3.695) AM7(-7.317,3.695) AM8(-6.668,3.695) AM10(-5.753,3.695) AM25(4.142,3.646) AM27(5.069,3.646) AM28(5.719,3.646) AM29(6.369,3.646) AM30(7.019,3.646) AM31(7.669,3.646) AM32(8.32,3.646) AM33(9.04,3.775) AM35(10.245,3.775) AN4(-9.365,3.098) AN5(-8.617,2.771) AN6(-7.967,2.771) AN7(-7.317,2.771) AN8(-6.668,2.771) AN9(-6.21,3.233) AN10(-5.753,2.771) AN24(3.679,3.19) AN25(4.142,2.734) AN26(4.606,3.19) AN27(5.069,2.734) AN28(5.719,2.734) AN29(6.369,2.734) AN30(7.019,2.734) AN31(7.669,2.734) AN32(8.32,2.734) AN34(9.365,3.168) AP3(-10.334,2.441) AP4(-9.325,2.441) AP9(-6.21,2.31) AP24(3.679,2.278) AP26(4.606,2.278) AP33(9.04,2.517) AP34(9.69,2.517) AR4(-9.365,1.783) AR5(-8.617,1.848) AR6(-7.967,1.848) AR7(-7.317,1.848) AR8(-6.668,1.848) AR10(-5.753,1.848) AR25(4.142,1.823) AR27(5.069,1.823) AR28(5.719,1.823) AR29(6.369,1.823) AR30(7.019,1.823) AR31(7.669,1.823) AR32(8.32,1.823) AR34(9.365,1.866) AT4(-9.69,1.22) AT9(-6.21,1.386) AT24(3.679,1.367) AT26(4.606,1.367) AT33(9.04,1.259) AT35(10.245,1.259) AU4(-9.365,0.657) AU5(-8.617,0.924) AU6(-7.967,0.924) AU7(-7.317,0.924) AU8(-6.668,0.924) AU9(-6.21,0.462) AU10(-5.753,0.924) AU24(3.679,0.456) AU25(4.142,0.911) AU26(4.606,0.456) AU27(5.069,0.911) AU28(5.719,0.911) AU29(6.369,0.911) AU30(7.019,0.911) AU31(7.669,0.911) AU32(8.32,0.911) AU34(9.365,0.65) AV3(-10.334,0) AV4(-9.325,0) AV5(-8.617,0) AV6(-7.967,0) AV7(-7.317,0) AV8(-6.668,0) AV10(-5.753,0) AV25(4.142,0) AV27(5.069,0) AV28(5.719,0) AV29(6.369,0) AV30(7.019,0) AV31(7.669,0) AV32(8.32,0) AV33(9.04,0) AV34(9.69,0) AW4(-9.365,-0.657) AW5(-8.617,-0.924) AW6(-7.967,-0.924) AW7(-7.317,-0.924) AW8(-6.668,-0.924) AW9(-6.21,-0.462) AW10(-5.753,-0.924) AW24(3.679,-0.456) AW25(4.142,-0.911) AW26(4.606,-0.456) AW27(5.069,-0.911) AW28(5.719,-0.911) AW29(6.369,-0.911) AW30(7.019,-0.911) AW31(7.669,-0.911) AW32(8.32,-0.911) AW34(9.365,-0.65) AY4(-9.69,-1.22) AY9(-6.21,-1.386) AY24(3.679,-1.367) AY26(4.606,-1.367) AY33(9.04,-1.259) AY35(10.245,-1.259) B4(-9.515,21.707) B5(-8.866,21.684) B33(8.901,22.004) B34(9.396,21.582) B35(10.037,21.687) BA4(-9.365,-1.783) BA5(-8.617,-1.848) BA6(-7.967,-1.848) BA7(-7.317,-1.848) BA8(-6.668,-1.848) BA10(-5.753,-1.848) BA25(4.142,-1.823) BA27(5.069,-1.823) BA28(5.719,-1.823) BA29(6.369,-1.823) BA30(7.019,-1.823) BA31(7.669,-1.823) BA32(8.32,-1.823) BA34(9.365,-1.866) BB3(-10.334,-2.441) BB4(-9.325,-2.441) BB9(-6.21,-2.31) BB24(3.679,-2.278) BB26(4.606,-2.278) BB33(9.04,-2.517) BB34(9.69,-2.517) BC4(-9.365,-3.098) BC5(-8.617,-2.771) BC6(-7.967,-2.771) BC7(-7.317,-2.771) BC8(-6.668,-2.771) BC9(-6.21,-3.233) BC10(-5.753,-2.771) BC24(3.679,-3.19) BC25(4.142,-2.734) BC26(4.606,-3.19) BC27(5.069,-2.734) BC28(5.719,-2.734) BC29(6.369,-2.734) BC30(7.019,-2.734) BC31(7.669,-2.734) BC32(8.32,-2.734) BC34(9.365,-3.168) BD4(-9.69,-3.661) BD5(-8.617,-3.695) BD6(-7.967,-3.695) BD7(-7.317,-3.695) BD8(-6.668,-3.695) BD10(-5.753,-3.695) BD25(4.142,-3.646) BD27(5.069,-3.646) BD28(5.719,-3.646) BD29(6.369,-3.646) BD30(7.019,-3.646) BD31(7.669,-3.646) BD32(8.32,-3.646) BD33(9.04,-3.775) BD35(10.245,-3.775) BE4(-9.365,-4.224) BE5(-8.617,-4.619) BE6(-7.967,-4.619) BE7(-7.317,-4.619) BE8(-6.668,-4.619) BE9(-6.21,-4.157) BE10(-5.753,-4.619) BE24(3.679,-4.101) BE25(4.142,-4.557) BE26(4.606,-4.101) BE27(5.069,-4.557) BE28(5.719,-4.557) BE29(6.369,-4.557) BE30(7.019,-4.557) BE31(7.669,-4.557) BE32(8.32,-4.557) BE34(9.365,-4.383) BF3(-10.334,-4.882) BF4(-9.325,-4.882) BF9(-6.21,-5.081) BF24(3.679,-5.013) BF26(4.606,-5.013) BF33(9.04,-5.034) BF34(9.69,-5.034) BG4(-9.365,-5.539) BG5(-8.617,-5.543) BG6(-7.967,-5.543) BG7(-7.317,-5.543) BG8(-6.668,-5.543) BG10(-5.753,-5.543) BG25(4.142,-5.468) BG27(5.069,-5.468) BG28(5.719,-5.468) BG29(6.369,-5.468) BG30(7.019,-5.468) BG31(7.669,-5.468) BG32(8.32,-5.468) BG34(9.365,-5.685) BH4(-9.69,-6.102) BH9(-6.21,-6.005) BH24(3.679,-5.924) BH25(4.142,-6.38) BH26(4.606,-5.924) BH27(5.069,-6.38) BH28(5.719,-6.38) BH29(6.369,-6.38) BH30(7.019,-6.38) BH31(7.669,-6.38) BH32(8.32,-6.38) BH33(9.04,-6.293) BH35(10.245,-6.293) BJ4(-9.365,-6.665) BJ5(-8.617,-6.467) BJ6(-7.967,-6.467) BJ7(-7.317,-6.467) BJ8(-6.668,-6.467) BJ9(-6.21,-6.929) BJ10(-5.753,-6.467) BJ24(3.679,-6.835) BJ26(4.606,-6.835) BJ34(9.365,-6.9) BK3(-10.334,-7.322) BK4(-9.325,-7.322) BK5(-8.617,-7.39) BK6(-7.967,-7.39) BK7(-7.317,-7.39) BK8(-6.668,-7.39) BK10(-5.753,-7.39) BK25(4.142,-7.291) BK27(5.069,-7.291) BK28(5.719,-7.291) BK29(6.369,-7.291) BK30(7.019,-7.291) BK31(7.669,-7.291) BK32(8.32,-7.291) BK33(9.04,-7.551) BK34(9.69,-7.551) BL4(-9.365,-7.98) BL5(-8.617,-8.314) BL6(-7.967,-8.314) BL7(-7.317,-8.314) BL8(-6.668,-8.314) BL9(-6.21,-7.852) BL10(-5.753,-8.314) BL24(3.679,-7.747) BL25(4.142,-8.203) BL26(4.606,-7.747) BL27(5.069,-8.203) BL28(5.719,-8.203) BL29(6.369,-8.203) BL30(7.019,-8.203) BL31(7.669,-8.203) BL32(8.32,-8.203) BL34(9.365,-8.202) BM4(-9.69,-8.543) BM9(-6.21,-8.776) BM24(3.679,-8.658) BM26(4.606,-8.658) BM33(9.04,-8.809) BM35(10.245,-8.809) BN4(-9.365,-9.106) BN5(-8.617,-9.238) BN6(-7.967,-9.238) BN7(-7.317,-9.238) BN8(-6.668,-9.238) BN10(-5.753,-9.238) BN25(4.142,-9.114) BN27(5.069,-9.114) BN28(5.719,-9.114) BN29(6.369,-9.114) BN30(7.019,-9.114) BN31(7.669,-9.114) BN32(8.32,-9.114) BN34(9.365,-9.417) BP3(-10.334,-9.763) BP4(-9.325,-9.763) BP5(-8.617,-10.162) BP6(-7.967,-10.162) BP7(-7.317,-10.162) BP8(-6.668,-10.162) BP9(-6.018,-10.162) BP11(-5.093,-9.786) BP12(-4.253,-9.786) BP14(-3.413,-9.786) BP15(-2.574,-9.786) BP16(-1.734,-9.786) BP18(-0.894,-9.786) BP19(-0.054,-9.786) BP20(0.786,-9.786) BP22(1.626,-9.786) BP23(2.465,-9.786) BP24(3.305,-9.786) BP25(4.145,-9.786) BP27(5.069,-10.025) BP28(5.719,-10.025) BP29(6.369,-10.025) BP30(7.019,-10.025) BP31(7.669,-10.025) BP32(8.32,-10.025) BP33(9.04,-10.068) BP34(9.69,-10.068) BR4(-9.365,-10.421) BR11(-5.093,-10.436) BR12(-4.253,-10.436) BR14(-3.413,-10.436) BR15(-2.574,-10.436) BR16(-1.734,-10.436) BR18(-0.894,-10.436) BR19(-0.054,-10.436) BR20(0.786,-10.436) BR22(1.626,-10.436) BR23(2.465,-10.436) BR24(3.305,-10.436) BR25(4.145,-10.436) BR34(9.365,-10.719) BT4(-9.69,-10.984) BT5(-8.617,-11.086) BT6(-7.967,-11.086) BT7(-7.317,-11.086) BT8(-6.668,-11.086) BT9(-6.018,-11.086) BT11(-5.093,-11.086) BT12(-4.253,-11.086) BT14(-3.413,-11.086) BT15(-2.574,-11.086) BT16(-1.734,-11.086) BT18(-0.894,-11.086) BT19(-0.054,-11.086) BT20(0.786,-11.086) BT22(1.626,-11.086) BT23(2.465,-11.086) BT24(3.305,-11.086) BT25(4.145,-11.086) BT27(5.069,-10.937) BT28(5.719,-10.937) BT29(6.369,-10.937) BT30(7.019,-10.937) BT31(7.669,-10.937) BT32(8.32,-10.937) BT33(9.04,-11.327) BT35(10.245,-11.327) BU4(-9.365,-11.547) BU5(-8.617,-12.009) BU6(-7.967,-12.009) BU7(-7.317,-12.009) BU8(-6.668,-12.009) BU9(-6.018,-12.009) BU11(-5.093,-11.736) BU12(-4.253,-11.736) BU14(-3.413,-11.736) BU15(-2.574,-11.736) BU16(-1.734,-11.736) BU18(-0.894,-11.736) BU19(-0.054,-11.736) BU20(0.786,-11.736) BU22(1.626,-11.736) BU23(2.465,-11.736) BU24(3.305,-11.736) BU25(4.145,-11.736) BU27(5.069,-11.848) BU28(5.719,-11.848) BU29(6.369,-11.848) BU30(7.019,-11.848) BU31(7.669,-11.848) BU32(8.32,-11.848) BU34(9.365,-11.934) BV3(-10.334,-12.204) BV4(-9.325,-12.204) BV11(-5.093,-12.386) BV12(-4.253,-12.386) BV14(-3.413,-12.386) BV15(-2.574,-12.386) BV16(-1.734,-12.386) BV18(-0.894,-12.386) BV19(-0.054,-12.386) BV20(0.786,-12.386) BV22(1.626,-12.386) BV23(2.465,-12.386) BV24(3.305,-12.386) BV25(4.145,-12.386) BV27(5.069,-12.76) BV28(5.719,-12.76) BV29(6.369,-12.76) BV30(7.019,-12.76) BV31(7.669,-12.76) BV32(8.32,-12.76) BV33(9.04,-12.585) BV34(9.69,-12.585) BW4(-9.365,-12.861) BW5(-8.617,-12.933) BW6(-7.967,-12.933) BW7(-7.317,-12.933) BW8(-6.668,-12.933) BW9(-6.018,-12.933) BW11(-5.093,-13.036) BW12(-4.253,-13.036) BW14(-3.413,-13.036) BW15(-2.574,-13.036) BW16(-1.734,-13.036) BW18(-0.894,-13.036) BW19(-0.054,-13.036) BW20(0.786,-13.036) BW22(1.626,-13.036) BW23(2.465,-13.036) BW24(3.305,-13.036) BW25(4.145,-13.036) BW34(9.365,-13.236) BY4(-9.69,-13.424) BY5(-8.617,-13.857) BY6(-7.967,-13.857) BY7(-7.317,-13.857) BY8(-6.668,-13.857) BY9(-6.018,-13.857) BY11(-5.093,-13.686) BY12(-4.253,-13.686) BY14(-3.413,-13.686) BY15(-2.574,-13.686) BY16(-1.734,-13.686) BY18(-0.894,-13.686) BY19(-0.054,-13.686) BY20(0.786,-13.686) BY22(1.626,-13.686) BY23(2.465,-13.686) BY24(3.305,-13.686) BY25(4.145,-13.686) BY27(5.069,-13.671) BY28(5.719,-13.671) BY29(6.369,-13.671) BY30(7.019,-13.671) BY31(7.669,-13.671) BY32(8.32,-13.671) BY33(9.04,-13.844) BY35(10.245,-13.844) C3(-10.059,21.059) C4(-9.213,21.132) C9(-6.305,21.245) C21(1.275,21.245) C25(3.792,21.245) C29(6.309,21.245) C33(8.826,21.245) C34(9.396,20.932) C35(10.037,21.037) C36(10.687,21.037) CA4(-9.365,-13.988) CA11(-5.093,-14.336) CA12(-4.253,-14.336) CA14(-3.413,-14.336) CA15(-2.574,-14.336) CA16(-1.734,-14.336) CA18(-0.894,-14.336) CA19(-0.054,-14.336) CA20(0.786,-14.336) CA22(1.626,-14.336) CA23(2.465,-14.336) CA24(3.305,-14.336) CA25(4.145,-14.336) CA27(5.069,-14.582) CA28(5.719,-14.582) CA29(6.369,-14.582) CA30(7.019,-14.582) CA31(7.669,-14.582) CA32(8.32,-14.582) CA34(9.365,-14.451) CB3(-10.334,-14.645) CB4(-9.325,-14.645) CB5(-8.617,-14.781) CB6(-7.967,-14.781) CB7(-7.317,-14.781) CB8(-6.668,-14.781) CB9(-6.018,-14.781) CB11(-5.093,-14.985) CB12(-4.253,-14.985) CB14(-3.413,-14.985) CB15(-2.574,-14.985) CB16(-1.734,-14.985) CB18(-0.894,-14.985) CB19(-0.054,-14.985) CB20(0.786,-14.985) CB22(1.626,-14.985) CB23(2.465,-14.985) CB24(3.305,-14.985) CB25(4.145,-14.985) CB33(9.04,-15.102) CB34(9.69,-15.102) CC4(-9.365,-15.302) CC5(-8.617,-15.705) CC6(-7.967,-15.705) CC7(-7.317,-15.705) CC8(-6.668,-15.705) CC9(-6.018,-15.705) CC11(-5.093,-15.635) CC12(-4.253,-15.635) CC14(-3.413,-15.635) CC15(-2.574,-15.635) CC16(-1.734,-15.635) CC18(-0.894,-15.635) CC19(-0.054,-15.635) CC20(0.786,-15.635) CC22(1.626,-15.635) CC23(2.465,-15.635) CC24(3.305,-15.635) CC25(4.145,-15.635) CC27(5.069,-15.494) CC28(5.719,-15.494) CC29(6.369,-15.494) CC30(7.019,-15.494) CC31(7.669,-15.494) CC32(8.32,-15.494) CC34(9.365,-15.753) CD4(-9.69,-15.865) CD11(-5.093,-16.285) CD12(-4.253,-16.285) CD14(-3.413,-16.285) CD15(-2.574,-16.285) CD16(-1.734,-16.285) CD18(-0.894,-16.285) CD19(-0.054,-16.285) CD20(0.786,-16.285) CD22(1.626,-16.285) CD23(2.465,-16.285) CD24(3.305,-16.285) CD25(4.145,-16.285) CE4(-9.365,-16.428) CE5(-8.617,-16.628) CE6(-7.967,-16.628) CE7(-7.317,-16.628) CE8(-6.668,-16.628) CE9(-6.018,-16.628) CE27(5.069,-16.405) CE28(5.719,-16.405) CE29(6.369,-16.405) CE30(7.019,-16.405) CE31(7.669,-16.405) CE32(8.32,-16.405) CE33(9.04,-16.36) CE35(10.245,-16.36) CF3(-10.334,-17.086) CF4(-9.325,-17.086) CF11(-5.37,-17.115) CF12(-4.368,-17.115) CF14(-3.33,-17.115) CF15(-2.292,-17.115) CF17(-1.254,-17.115) CF19(-0.216,-17.115) CF20(0.822,-17.115) CF22(1.86,-17.115) CF23(2.898,-17.115) CF25(3.936,-17.115) CF27(5.069,-17.317) CF28(5.719,-17.317) CF29(6.369,-17.317) CF30(7.019,-17.317) CF31(7.669,-17.317) CF32(8.32,-17.317) CF34(9.365,-16.968) CG4(-9.365,-17.743) CG5(-8.617,-17.552) CG6(-7.967,-17.552) CG7(-7.317,-17.552) CG8(-6.668,-17.552) CG9(-6.018,-17.552) CG11(-5.37,-17.765) CG12(-4.368,-17.765) CG14(-3.33,-17.765) CG15(-2.292,-17.765) CG17(-1.254,-17.765) CG19(-0.216,-17.765) CG20(0.822,-17.765) CG22(1.86,-17.765) CG23(2.898,-17.765) CG25(3.936,-17.765) CG33(9.04,-17.619) CG34(9.69,-17.619) CH4(-9.69,-18.306) CH5(-8.617,-18.476) CH6(-7.967,-18.476) CH7(-7.317,-18.476) CH8(-6.668,-18.476) CH9(-6.018,-18.476) CH11(-5.37,-18.415) CH12(-4.368,-18.415) CH14(-3.33,-18.415) CH15(-2.292,-18.415) CH17(-1.254,-18.415) CH19(-0.216,-18.415) CH20(0.822,-18.415) CH22(1.86,-18.415) CH23(2.898,-18.415) CH25(3.936,-18.415) CH27(5.069,-18.228) CH28(5.719,-18.228) CH29(6.369,-18.228) CH30(7.019,-18.228) CH31(7.669,-18.228) CH32(8.32,-18.228) CH34(9.365,-18.27) CJ4(-9.365,-18.869) CJ11(-5.37,-19.065) CJ12(-4.368,-19.065) CJ14(-3.33,-19.065) CJ15(-2.292,-19.065) CJ17(-1.254,-19.065) CJ19(-0.216,-19.065) CJ20(0.822,-19.065) CJ22(1.86,-19.065) CJ23(2.898,-19.065) CJ25(3.936,-19.065) CJ27(5.069,-19.139) CJ28(5.719,-19.139) CJ29(6.369,-19.139) CJ30(7.019,-19.139) CJ31(7.669,-19.139) CJ32(8.32,-19.139) CJ33(9.04,-18.833) CJ35(10.245,-18.878) CK1(-11.315,-19.561) CK3(-9.895,-19.83) CK4(-9.325,-19.518) CK5(-8.617,-19.4) CK6(-7.967,-19.4) CK7(-7.317,-19.4) CK8(-6.668,-19.4) CK9(-6.018,-19.4) CK11(-5.37,-19.715) CK12(-4.368,-19.715) CK14(-3.33,-19.715) CK15(-2.292,-19.715) CK17(-1.254,-19.715) CK19(-0.216,-19.715) CK20(0.822,-19.715) CK22(1.86,-19.715) CK23(2.898,-19.715) CK25(3.936,-19.715) CK33(9.15,-19.504) CK34(9.775,-19.326) CK36(10.612,-19.462) CK37(11.315,-19.374) CL2(-10.896,-20.058) CL35(10.061,-19.91) CL36(10.948,-20.019) CM1(-11.315,-20.555) CM3(-10.333,-20.383) CM4(-9.496,-20.343) CM5(-8.782,-20.365) CM6(-8.132,-20.371) CM7(-7.565,-20.69) CM8(-6.999,-20.371) CM9(-6.305,-20.365) CM10(-5.61,-20.371) CM11(-5.044,-20.69) CM12(-4.478,-20.371) CM13(-3.783,-20.365) CM14(-3.088,-20.371) CM15(-2.522,-20.69) CM16(-1.956,-20.371) CM17(-1.261,-20.365) CM18(-0.566,-20.371) CM19(0,-20.69) CM20(0.566,-20.371) CM21(1.261,-20.365) CM22(1.956,-20.371) CM23(2.522,-20.69) CM24(3.088,-20.371) CM25(3.783,-20.365) CM26(4.478,-20.371) CM27(5.044,-20.69) CM28(5.61,-20.371) CM29(6.305,-20.365) CM30(6.955,-20.365) CM31(7.531,-20.814) CM32(8.176,-20.365) CM33(8.826,-20.365) CM34(9.471,-20.286) CM35(10.447,-20.433) CM37(11.315,-20.555) CN2(-10.752,-20.88) CN3(-10.007,-20.946) CN4(-9.358,-20.978) CN5(-8.794,-21.367) CN9(-6.305,-21.245) CN13(-3.783,-21.245) CN17(-1.261,-21.245) CN21(1.261,-21.245) CN25(3.783,-21.245) CN29(6.305,-21.245) CN33(8.826,-21.245) CN34(9.396,-20.932) CN35(10.037,-21.037) CN36(10.687,-21.037) CP3(-10.037,-21.687) CP4(-9.39,-21.627) CP5(-8.942,-22.099) CP33(8.871,-21.968) CP34(9.396,-21.582) CP35(10.037,-21.687) CR4(-9.555,-22.315) CR6(-8.232,-22.315) CR32(8.321,-22.315) CR34(9.555,-22.315) D2(-10.64,20.579) D4(-9.594,20.605) D5(-8.782,20.365) D6(-8.132,20.371) D7(-7.565,20.69) D8(-6.999,20.371) D9(-6.305,20.505) D21(1.275,20.595) D22(1.883,20.365) D23(2.534,20.69) D24(3.184,20.365) D25(3.792,20.595) D26(4.4,20.365) D27(5.051,20.69) D28(5.701,20.365) D30(6.917,20.365) D31(7.568,20.69) D32(8.218,20.365) D34(9.396,20.282) D35(10.447,20.433) D37(11.315,20.555) E1(-11.315,20.096) E3(-10.008,20.089) E4(-9.365,19.995) E9(-6.21,19.862) E23(2.621,20.04) E27(5.051,20.04) E29(6.309,20.04) E31(7.568,20.04) E33(8.781,20.04) E35(10.061,19.91) E36(10.948,20.019) F2(-11.001,19.527) F3(-10.334,19.527) F4(-9.69,19.432) F5(-8.617,19.4) F6(-7.967,19.4) F7(-7.317,19.4) F8(-6.668,19.4) F21(1.149,19.715) F22(2.058,19.715) F24(3.184,19.715) F25(4.093,19.715) F33(9.15,19.504) F34(9.775,19.326) F36(10.612,19.462) F37(11.315,19.374) G1(-11.315,18.844) G4(-9.365,18.869) G9(-6.21,18.938) G21(1.149,19.065) G22(2.058,19.065) G24(3.184,19.065) G25(4.093,19.065) G27(5.069,19.139) G28(5.719,19.139) G29(6.369,19.139) G30(7.019,19.139) G31(7.669,19.139) G32(8.32,19.139) G33(9.04,18.833) G35(10.245,18.878) H4(-9.69,18.306) H5(-8.617,18.476) H6(-7.967,18.476) H7(-7.317,18.476) H8(-6.668,18.476) H9(-6.21,18.014) H21(1.149,18.415) H22(2.058,18.415) H24(3.184,18.415) H25(4.093,18.415) H27(5.069,18.228) H28(5.719,18.228) H29(6.369,18.228) H30(7.019,18.228) H31(7.669,18.228) H32(8.32,18.228) H34(9.365,18.27) J4(-9.365,17.743) J5(-8.617,17.552) J6(-7.967,17.552) J7(-7.317,17.552) J8(-6.668,17.552) J21(1.149,17.765) J22(2.058,17.765) J24(3.184,17.765) J25(4.093,17.765) J33(9.04,17.619) J34(9.69,17.619) K3(-10.334,17.086) K4(-9.325,17.086) K9(-6.21,17.09) K11(-5.322,17.115) K12(-4.38,17.115) K14(-3.438,17.115) K15(-2.496,17.115) K17(-1.554,17.115) K18(-0.613,17.115) K20(0.329,17.115) K21(1.149,17.115) K22(2.058,17.115) K24(3.184,17.115) K25(4.093,17.115) K27(5.069,17.317) K28(5.719,17.317) K29(6.369,17.317) K30(7.019,17.317) K31(7.669,17.317) K32(8.32,17.317) K34(9.365,16.968) L4(-9.365,16.428) L5(-8.617,16.628) L6(-7.967,16.628) L7(-7.317,16.628) L8(-6.668,16.628) L10(-5.753,16.628) L25(4.142,16.405) L27(5.069,16.405) L28(5.719,16.405) L29(6.369,16.405) L30(7.019,16.405) L31(7.669,16.405) L32(8.32,16.405) L33(9.04,16.36) L35(10.245,16.36) M4(-9.69,15.865) M9(-6.21,16.167) M24(3.679,15.949) M26(4.606,15.949) N4(-9.365,15.302) N5(-8.617,15.705) N6(-7.967,15.705) N7(-7.317,15.705) N8(-6.668,15.705) N9(-6.21,15.243) N10(-5.753,15.705) N25(4.142,15.494) N27(5.069,15.494) N28(5.719,15.494) N29(6.369,15.494) N30(7.019,15.494) N31(7.669,15.494) N32(8.32,15.494) N34(9.365,15.753) P3(-10.334,14.645) P4(-9.325,14.645) P5(-8.617,14.781) P6(-7.967,14.781) P7(-7.317,14.781) P8(-6.668,14.781) P10(-5.753,14.781) P24(3.679,15.038) P26(4.606,15.038) P33(9.04,15.102) P34(9.69,15.102) R4(-9.365,13.988) R9(-6.21,14.319) R24(3.679,14.127) R25(4.142,14.582) R26(4.606,14.127) R27(5.069,14.582) R28(5.719,14.582) R29(6.369,14.582) R30(7.019,14.582) R31(7.669,14.582) R32(8.32,14.582) R34(9.365,14.451) T4(-9.69,13.424) T5(-8.617,13.857) T6(-7.967,13.857) T7(-7.317,13.857) T8(-6.668,13.857) T9(-6.21,13.395) T10(-5.753,13.857) T25(4.142,13.671) T27(5.069,13.671) T28(5.719,13.671) T29(6.369,13.671) T30(7.019,13.671) T31(7.669,13.671) T32(8.32,13.671) T33(9.04,13.844) T35(10.245,13.844) U4(-9.365,12.861) U5(-8.617,12.933) U6(-7.967,12.933) U7(-7.317,12.933) U8(-6.668,12.933) U10(-5.753,12.933) U24(3.679,13.215) U26(4.606,13.215) U34(9.365,13.236) V3(-10.334,12.204) V4(-9.325,12.204) V9(-6.21,12.471) V24(3.679,12.304) V25(4.142,12.76) V26(4.606,12.304) V27(5.069,12.76) V28(5.719,12.76) V29(6.369,12.76) V30(7.019,12.76) V31(7.669,12.76) V32(8.32,12.76) V33(9.04,12.585) V34(9.69,12.585) W4(-9.365,11.547) W5(-8.617,12.009) W6(-7.967,12.009) W7(-7.317,12.009) W8(-6.668,12.009) W9(-6.21,11.548) W10(-5.753,12.009) W25(4.142,11.848) W27(5.069,11.848) W28(5.719,11.848) W29(6.369,11.848) W30(7.019,11.848) W31(7.669,11.848) W32(8.32,11.848) W34(9.365,11.934) Y4(-9.69,10.984) Y5(-8.617,11.086) Y6(-7.967,11.086) Y7(-7.317,11.086) Y8(-6.668,11.086) Y10(-5.753,11.086) Y24(3.679,11.392) Y25(4.142,10.937) Y26(4.606,11.392) Y27(5.069,10.937) Y28(5.719,10.937) Y29(6.369,10.937) Y30(7.019,10.937) Y31(7.669,10.937) Y32(8.32,10.937) Y33(9.04,11.327) Y35(10.245,11.327)
  oval 0.254x0.343 smd: A8(-6.915,22.315) A22(1.883,22.315) A24(3.184,22.315) A26(4.4,22.315) A28(5.701,22.315) A30(6.917,22.315) B6(-8.216,21.665) B7(-7.565,21.99) B8(-6.915,21.665) B9(-6.305,21.895) B21(1.275,21.895) B22(1.883,21.665) B23(2.534,21.99) B24(3.184,21.665) B25(3.792,21.895) B26(4.4,21.665) B27(5.051,21.99) B28(5.701,21.665) B29(6.309,21.895) B30(6.917,21.665) B31(7.568,21.99) B32(8.218,21.665) C6(-8.216,21.015) C7(-7.565,21.34) C8(-6.999,21.021) C22(1.883,21.015) C23(2.534,21.34) C24(3.184,21.015) C26(4.4,21.015) C27(5.051,21.34) C28(5.701,21.015) C30(6.917,21.015) C31(7.568,21.34) C32(8.218,21.015) CN6(-8.216,-21.015) CN7(-7.565,-21.34) CN8(-6.999,-21.021) CN10(-5.61,-21.021) CN11(-5.044,-21.34) CN12(-4.478,-21.021) CN14(-3.088,-21.021) CN15(-2.522,-21.34) CN16(-1.956,-21.021) CN18(-0.566,-21.021) CN19(0,-21.34) CN20(0.566,-21.021) CN22(1.956,-21.021) CN23(2.522,-21.34) CN24(3.088,-21.021) CN26(4.478,-21.021) CN27(5.044,-21.34) CN28(5.61,-21.021) CN30(6.912,-21.014) CN31(7.605,-21.461) CN32(8.219,-21.014) CP6(-8.216,-21.665) CP7(-7.565,-21.99) CP8(-6.915,-21.665) CP9(-6.305,-21.895) CP10(-5.694,-21.665) CP11(-5.044,-21.99) CP12(-4.393,-21.665) CP13(-3.783,-21.895) CP14(-3.172,-21.665) CP15(-2.522,-21.99) CP16(-1.871,-21.665) CP17(-1.261,-21.895) CP18(-0.65,-21.665) CP19(0,-21.99) CP20(0.65,-21.665) CP21(1.261,-21.895) CP22(1.871,-21.665) CP23(2.522,-21.99) CP24(3.172,-21.665) CP25(3.783,-21.895) CP26(4.393,-21.665) CP27(5.044,-21.99) CP28(5.694,-21.665) CP29(6.305,-21.895) CP30(6.983,-21.669) CP31(7.605,-22.19) CP32(8.296,-21.665) CR8(-6.915,-22.315) CR10(-5.694,-22.315) CR12(-4.393,-22.315) CR14(-3.172,-22.315) CR16(-1.871,-22.315) CR18(-0.65,-22.315) CR20(0.65,-22.315) CR22(1.871,-22.315) CR24(3.172,-22.315) CR26(4.393,-22.315) CR28(5.694,-22.315) CR30(6.912,-22.315)
  round 0.406 smd: A11(-5.322,22.315) A12(-4.38,22.315) A14(-3.438,22.315) A15(-2.496,22.315) A17(-1.554,22.315) A18(-0.613,22.315) A20(0.329,22.315) B11(-5.322,21.665) B12(-4.38,21.665) B14(-3.438,21.665) B15(-2.496,21.665) B17(-1.554,21.665) B18(-0.613,21.665) B20(0.329,21.665) C11(-5.322,21.015) C12(-4.38,21.015) C14(-3.438,21.015) C15(-2.496,21.015) C17(-1.554,21.015) C18(-0.613,21.015) C20(0.329,21.015) D11(-5.322,20.365) D12(-4.38,20.365) D14(-3.438,20.365) D15(-2.496,20.365) D17(-1.554,20.365) D18(-0.613,20.365) D20(0.329,20.365) F11(-5.322,19.715) F12(-4.38,19.715) F14(-3.438,19.715) F15(-2.496,19.715) F17(-1.554,19.715) F18(-0.613,19.715) F20(0.329,19.715) G11(-5.322,19.065) G12(-4.38,19.065) G14(-3.438,19.065) G15(-2.496,19.065) G17(-1.554,19.065) G18(-0.613,19.065) G20(0.329,19.065) H11(-5.322,18.415) H12(-4.38,18.415) H14(-3.438,18.415) H15(-2.496,18.415) H17(-1.554,18.415) H18(-0.613,18.415) H20(0.329,18.415) J11(-5.322,17.765) J12(-4.38,17.765) J14(-3.438,17.765) J15(-2.496,17.765) J17(-1.554,17.765) J18(-0.613,17.765) J20(0.329,17.765)
  oval 0.343x0.254 smd: AA1(-11.315,10.421) AA2(-10.665,10.421) AA3(-10.015,10.421) AA35(10.015,10.719) AA36(10.665,10.719) AA37(11.315,10.719) AB2(-10.99,9.763) AB35(10.34,10.068) AB36(10.99,10.068) AC1(-11.315,9.106) AC2(-10.665,9.106) AC3(-10.015,9.106) AC35(10.015,9.417) AC36(10.665,9.417) AC37(11.315,9.417) AD3(-10.34,8.543) AD36(10.895,8.809) AE1(-11.315,7.98) AE2(-10.665,7.98) AE3(-10.015,7.98) AE35(10.015,8.202) AE36(10.665,8.202) AE37(11.315,8.202) AF2(-10.99,7.322) AF35(10.34,7.551) AF36(10.99,7.551) AG1(-11.315,6.665) AG2(-10.665,6.665) AG3(-10.015,6.665) AG35(10.015,6.9) AG36(10.665,6.9) AG37(11.315,6.9) AH3(-10.34,6.102) AH36(10.895,6.293) AJ1(-11.315,5.539) AJ2(-10.665,5.539) AJ3(-10.015,5.539) AJ35(10.015,5.685) AJ36(10.665,5.685) AJ37(11.315,5.685) AK2(-10.99,4.882) AK35(10.34,5.034) AK36(10.99,5.034) AL1(-11.315,4.224) AL2(-10.665,4.224) AL3(-10.015,4.224) AL35(10.015,4.383) AL36(10.665,4.383) AL37(11.315,4.383) AM3(-10.34,3.661) AM36(10.895,3.775) AN1(-11.315,3.098) AN2(-10.665,3.098) AN3(-10.015,3.098) AN35(10.015,3.168) AN36(10.665,3.168) AN37(11.315,3.168) AP2(-10.99,2.441) AP35(10.34,2.517) AP36(10.99,2.517) AR1(-11.315,1.783) AR2(-10.665,1.783) AR3(-10.015,1.783) AR35(10.015,1.866) AR36(10.665,1.866) AR37(11.315,1.866) AT3(-10.34,1.22) AT36(10.895,1.259) AU1(-11.315,0.657) AU2(-10.665,0.657) AU3(-10.015,0.657) AU35(10.015,0.65) AU36(10.665,0.65) AU37(11.315,0.65) AV2(-10.99,0) AV35(10.34,0) AV36(10.99,0) AW1(-11.315,-0.657) AW2(-10.665,-0.657) AW3(-10.015,-0.657) AW35(10.015,-0.65) AW36(10.665,-0.65) AW37(11.315,-0.65) AY3(-10.34,-1.22) AY36(10.895,-1.259) BA1(-11.315,-1.783) BA2(-10.665,-1.783) BA3(-10.015,-1.783) BA35(10.015,-1.866) BA36(10.665,-1.866) BA37(11.315,-1.866) BB2(-10.99,-2.441) BB35(10.34,-2.517) BB36(10.99,-2.517) BC1(-11.315,-3.098) BC2(-10.665,-3.098) BC3(-10.015,-3.098) BC35(10.015,-3.168) BC36(10.665,-3.168) BC37(11.315,-3.168) BD3(-10.34,-3.661) BD36(10.895,-3.775) BE1(-11.315,-4.224) BE2(-10.665,-4.224) BE3(-10.015,-4.224) BE35(10.015,-4.383) BE36(10.665,-4.383) BE37(11.315,-4.383) BF2(-10.99,-4.882) BF35(10.34,-5.034) BF36(10.99,-5.034) BG1(-11.315,-5.539) BG2(-10.665,-5.539) BG3(-10.015,-5.539) BG35(10.015,-5.685) BG36(10.665,-5.685) BG37(11.315,-5.685) BH3(-10.34,-6.102) BH36(10.895,-6.293) BJ1(-11.315,-6.665) BJ2(-10.665,-6.665) BJ3(-10.015,-6.665) BJ35(10.015,-6.9) BJ36(10.665,-6.9) BJ37(11.315,-6.9) BK2(-10.99,-7.322) BK35(10.34,-7.551) BK36(10.99,-7.551) BL1(-11.315,-7.98) BL2(-10.665,-7.98) BL3(-10.015,-7.98) BL35(10.015,-8.202) BL36(10.665,-8.202) BL37(11.315,-8.202) BM3(-10.34,-8.543) BM36(10.895,-8.809) BN1(-11.315,-9.106) BN2(-10.665,-9.106) BN3(-10.015,-9.106) BN35(10.015,-9.417) BN36(10.665,-9.417) BN37(11.315,-9.417) BP2(-10.99,-9.763) BP35(10.34,-10.068) BP36(10.99,-10.068) BR1(-11.315,-10.421) BR2(-10.665,-10.421) BR3(-10.015,-10.421) BR35(10.015,-10.719) BR36(10.665,-10.719) BR37(11.315,-10.719) BT3(-10.34,-10.984) BT36(10.895,-11.327) BU1(-11.315,-11.547) BU2(-10.665,-11.547) BU3(-10.015,-11.547) BU35(10.015,-11.934) BU36(10.665,-11.934) BU37(11.315,-11.934) BV2(-10.99,-12.204) BV35(10.34,-12.585) BV36(10.99,-12.585) BW1(-11.315,-12.861) BW2(-10.665,-12.861) BW3(-10.015,-12.861) BW35(10.015,-13.236) BW36(10.665,-13.236) BW37(11.315,-13.236) BY3(-10.34,-13.424) BY36(10.895,-13.844) CA1(-11.315,-13.988) CA2(-10.665,-13.988) CA3(-10.015,-13.988) CA35(10.015,-14.451) CA36(10.665,-14.451) CA37(11.315,-14.451) CB2(-10.99,-14.645) CB35(10.34,-15.102) CB36(10.99,-15.102) CC1(-11.315,-15.302) CC2(-10.665,-15.302) CC3(-10.015,-15.302) CC35(10.015,-15.753) CC36(10.665,-15.753) CC37(11.315,-15.753) CD3(-10.34,-15.865) CE1(-11.315,-16.428) CE2(-10.665,-16.428) CE3(-10.015,-16.428) CE36(10.895,-16.36) CF2(-10.99,-17.086) CF35(10.015,-16.968) CF36(10.665,-16.968) CF37(11.315,-16.968) CG1(-11.315,-17.743) CG2(-10.665,-17.743) CG3(-10.015,-17.743) CG35(10.34,-17.619) CG36(10.99,-17.619) CH3(-10.34,-18.306) CH35(10.015,-18.27) CH36(10.665,-18.27) CH37(11.315,-18.27) CJ1(-11.315,-18.869) CJ2(-10.665,-18.869) CJ3(-10.015,-18.869) CJ36(10.895,-18.878) CK2(-10.485,-19.555) G2(-10.665,18.869) G3(-10.015,18.869) G36(10.895,18.878) H3(-10.34,18.306) H35(10.015,18.27) H36(10.665,18.27) H37(11.315,18.27) J1(-11.315,17.743) J2(-10.665,17.743) J3(-10.015,17.743) J35(10.34,17.619) J36(10.99,17.619) K2(-10.99,17.086) K35(10.015,16.968) K36(10.665,16.968) K37(11.315,16.968) L1(-11.315,16.428) L2(-10.665,16.428) L3(-10.015,16.428) L36(10.895,16.36) M3(-10.34,15.865) N1(-11.315,15.302) N2(-10.665,15.302) N3(-10.015,15.302) N35(10.015,15.753) N36(10.665,15.753) N37(11.315,15.753) P2(-10.99,14.645) P35(10.34,15.102) P36(10.99,15.102) R1(-11.315,13.988) R2(-10.665,13.988) R3(-10.015,13.988) R35(10.015,14.451) R36(10.665,14.451) R37(11.315,14.451) T3(-10.34,13.424) T36(10.895,13.844) U1(-11.315,12.861) U2(-10.665,12.861) U3(-10.015,12.861) U35(10.015,13.236) U36(10.665,13.236) U37(11.315,13.236) V2(-10.99,12.204) V35(10.34,12.585) V36(10.99,12.585) W1(-11.315,11.547) W2(-10.665,11.547) W3(-10.015,11.547) W35(10.015,11.934) W36(10.665,11.934) W37(11.315,11.934) Y3(-10.34,10.984) Y36(10.895,11.327)
C0201H13
  custom 0.076x0.076 smd: 1(0,0.279) 2(0,-0.279)
C0201H14
  custom 0.076x0.076 smd: 1(0,0.279) 2(0,-0.279)
C402-TO0D2H28
  custom 0.14x0.14 smd: 1(0,0.457) 2(0,-0.457)
C402H22
  custom 0.114x0.114 smd: 1(0,0.457) 2(0,-0.457)
C402H24
  custom 0.114x0.114 smd: 1(0,0.457) 2(0,-0.457)
C603H32
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C603H36
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C603H38
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C603H40
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C805H54
  rect 1.473x0.889 smd: 1(0,0.838) 2(0,-0.838)
C805H56
  rect 1.473x0.889 smd: 1(0,0.838) 2(0,-0.838)
C805H58
  rect 1.473x0.889 smd: 1(0,0.838) 2(0,-0.838)
C1808H56
  rect 2.235x1.143 smd: 1(0,2.057) 2(0,-2.057)
CON2O-U
  custom 0.159x0.159 smd: 1(0,0.254) 2(0,-0.254)
CSP15G154256H24
  round 0.356 smd: A1(0.5,1) A2(0,1) A3(-0.5,1) B1(0.5,0.5) B2(0,0.5) B3(-0.5,0.5) C1(0.5,0) C2(0,0) C3(-0.5,0) D1(0.5,-0.5) D2(0,-0.5) D3(-0.5,-0.5) E1(0.5,-1) E2(0,-1) E3(-0.5,-1)
CSP16G2D2H24
  round 0.356 smd: A1(-0.75,0.75) A2(-0.25,0.75) A3(0.25,0.75) A4(0.75,0.75) B1(-0.75,0.25) B2(-0.25,0.25) B3(0.25,0.25) B4(0.75,0.25) C1(-0.75,-0.25) C2(-0.25,-0.25) C3(0.25,-0.25) C4(0.75,-0.25) D1(-0.75,-0.75) D2(-0.25,-0.75) D3(0.25,-0.75) D4(0.75,-0.75)
CT3528H79
  rect 2.286x1.372 smd: 1(0,1.448) 2(0,-1.448)
CT7343H79
  rect 2.413x1.905 smd: 1(0,2.959) 2(0,-2.959)
CT7343H83
  rect 2.413x1.905 smd: 1(0,2.959) 2(0,-2.959)
D1006-0305AK-UH22
  rect 0.61x0.432 smd: A(0,0.34) K(0,-0.34)
D1608AK-UH28
  rect 0.559x0.711 smd: A(0,0.702) K(0,-0.702)
D4724AKH44
  rect 2.007x1.295 smd: A(0,2.094) K(0,-2.094)
DFN6F2-G1711-UH32
  rect 0.406x0.508 smd: 1(0.65,1.067) 2(0,1.067) 3(-0.65,1.067) 4(-0.65,-1.067) 5(0,-1.067) 6(0.65,-1.067)
  rect 1.702x1.092 smd: 7(0,0)
DFN6G1820-G1511-UH24
  rect 0.305x0.508 smd: 1(0.5,1.006) 2(0,1.006) 3(-0.5,1.006) 4(-0.5,-1.006) 5(0,-1.006) 6(0.5,-1.006)
  rect 1.499x1.092 smd: 7(0,0)
DFN8-G125065H32
  rect 0.305x0.711 smd: 1(0.75,0.965) 2(0.25,0.965) 3(-0.25,0.965) 4(-0.75,0.965) 5(-0.75,-0.965) 6(-0.25,-0.965) 7(0.25,-0.965) 8(0.75,-0.965)
  rect 1.245x0.66 smd: 9(0,0)
DFN8A5060-G4135H32
  rect 0.635x1.118 smd: 1(1.905,2.695) 2(0.635,2.695) 3(-0.635,2.695) 4(-1.905,2.695) 5(-1.905,-2.695) 6(-0.635,-2.695) 7(0.635,-2.695) 8(1.905,-2.695)
  rect 4.089x3.505 smd: 9(0,0)
DFN8F3-G2517H32
  rect 0.406x0.686 smd: 1(0.975,1.411) 2(0.325,1.411) 3(-0.325,1.411) 4(-0.975,1.411) 5(-0.975,-1.411)
  rect 0.025x0.025 smd: 6(-0.325,-1.411) 8(0.975,-1.411)
  custom 0.171x0.171 smd: 7(0.325,-1.411)
  rect 2.489x1.676 smd: 9(0,0)
DFN8G2-G1710-U1H40
  rect 0.305x0.559 smd: 1(0.75,1.043) 2(0.25,1.043) 3(-0.25,1.043) 4(-0.75,1.043) 5(-0.75,-1.043) 6(-0.25,-1.043) 7(0.25,-1.043) 8(0.75,-1.043)
  rect 1.702x0.94 smd: 9(0,0)
DFN10G2510H22
  rect 0.305x0.66 smd: 1(1,0.43) 5(-1,0.43) 6(-1,-0.43) 10(1,-0.43)
  rect 0.254x0.66 smd: 2(0.521,0.43) 4(-0.521,0.43) 7(-0.521,-0.43) 9(0.521,-0.43)
  rect 0.025x0.025 smd: 3(0,0.43)
  rect 0.406x1.499 smd: 8(0,-0.43)
DFN14J32-G255D95H32
  custom 0.14x0.14 smd: 1(1.2,0.975) 6(-0.8,0.975) 8(-1.2,-0.975) 13(0.8,-0.975)
  rect 0.025x0.025 smd: 2(0.8,0.975) 7(-1.2,0.975) 9(-0.8,-0.975) 14(1.2,-0.975)
  rect 0.203x0.559 smd: 3(0.4,0.975) 4(0,0.975) 5(-0.4,0.975) 10(-0.4,-0.975) 11(0,-0.975) 12(0.4,-0.975)
  rect 2.54x0.94 smd: 15(0,0)
FFSKL05007N12C
  rect 0.305x1.092 smd: 1(-2.75,3.3) 2(-2.25,3.3) 3(-1.75,3.3) 4(-1.25,3.3) 5(-0.75,3.3) 6(-0.25,3.3) 7(0.25,3.3) 8(0.75,3.3) 9(1.25,3.3) 10(1.75,3.3) 11(2.25,3.3) 12(2.75,3.3)
  rect 1.448x2.007 smd: 13(-5.125,0) 14(5.125,0)
FH52-8S-D5SH
  rect 0.305x0.838 smd: 1(-1.75,3.175) 2(-1.25,3.175) 3(-0.75,3.175) 4(-0.25,3.175) 5(0.25,3.175) 6(0.75,3.175) 7(1.25,3.175) 8(1.75,3.175)
  rect 0.813x2.007 smd: 9(3.45,0) 10(-3.45,0)
GAP-CLOSE-PWR
  rect 0.66x0.762 smd: 1(-0.305,0) 2(0.305,0)
GAP-CLOSE-PWR-3
  rect 0.66x0.762 smd: 1(-0.305,0) 2(0.305,0)
GAP-CLOSE-PWR-0805-NP
  custom 0.34x0.34 smd: 1(0,0.681)
  custom 0.339x0.339 smd: 2(0,-0.681)
GAP-CLOSE-PWR-0805-NP-5
  custom 0.327x0.327 smd: 1(0,0.654) 2(0,-0.654)
HOLE233R142
  round 5.918 hole 3.607: 1(0,0)
HOLE256R115
  round 6.502 hole 2.921: 1(0,0)
HOLE335R178
  round 8.509 hole 4.521: 1(0,0)
HOLE335R229
  round 8.509 hole 5.817: 1(0,0)
L402H24
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
L603H38
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
L2520-D620H48
  rect 2.261x1.118 smd: 1(0,0.955) 2(0,-0.955)
L4947-1115H119
  rect 2.007x2.007 smd: 1(0,1.922) 2(0,-1.922)
L7066-1830-UH119
  rect 3.505x2.667 smd: 1(0,2.653) 2(0,-2.653)
L7366-1830H119
  rect 3.505x2.692 smd: 1(0,2.815) 2(0,-2.815)
L7366-1930H158
  rect 3.505x2.819 smd: 1(0,2.729) 2(0,-2.729)
L20125H42
  rect 1.346x0.94 smd: 1(0,0.838) 2(0,-0.838)
L125100-4P-3H24
  rect 0.356x0.635 smd: 1(-0.275,-0.559) 2(0.275,-0.559) 3(0.275,0.559) 4(-0.275,0.559)
L125100-4P-4H24
  rect 0.635x0.432 smd: 1(-0.562,0.341) 2(0.562,0.341) 3(0.562,-0.341) 4(-0.562,-0.341)
L125100-4P-4H28
  rect 0.635x0.432 smd: 1(-0.562,0.341) 2(0.562,0.341) 3(0.562,-0.341) 4(-0.562,-0.341)
L125100-4P-5H24
  rect 0.457x0.711 smd: 1(-0.326,0.523) 2(0.326,0.523) 3(-0.326,-0.523) 4(0.326,-0.523)
L11510030H158
  rect 3.505x3.632 smd: 1(0,4.435) 2(0,-4.435)
LED3020-3P-19H44
  rect 1.499x0.991 smd: 1(0,1.5) 3(0,-1.5)
  rect 0.889x0.889 smd: 2(0.65,0)
LED11516AKH28
  rect 0.94x0.813 smd: A(0,0.648) K(0,-0.648)
LGA12G2H40
  rect 0.381x0.381 smd: 1(0.809,0.809) 4(-0.809,0.809) 7(-0.809,-0.809) 10(0.809,-0.809)
  rect 0.305x0.432 smd: 2(0.25,0.784) 3(-0.25,0.784) 8(-0.25,-0.784) 9(0.25,-0.784)
  rect 0.432x0.305 smd: 5(-0.784,0.25) 6(-0.784,-0.25) 11(0.784,-0.25) 12(0.784,0.25)
MSOP8-1H44
  rect 0.356x1.397 smd: 1(-0.975,-1.991) 2(-0.325,-1.991) 3(0.325,-1.991) 4(0.975,-1.991) 5(0.975,1.991) 6(0.325,1.991) 7(-0.325,1.991) 8(-0.975,1.991)
MSS3-Q-T-R
  round 0.254 hole 0.965 unplated: (-1.5,0) (1.5,0)
  rect 0.61x1.499 smd: 1(-2.25,1.75) 2(0.751,1.75) 3(2.25,1.75)
  rect 0.991x0.813 smd: 4(-3.65,1.056) 5(-3.65,-1.056) 6(3.65,1.056) 7(3.65,-1.056)
NFSM0-S6701-TSH4-U
  round 0.254 hole 1.168 unplated: (-10,0)
  round 0.254 hole 1.651 unplated: (10,0)
  rect 0.305x1.346 smd: 1(-9.25,5.173) 2(-9,-2.173) 3(-8.75,5.173) 4(-8.5,-2.173) 5(-8.25,5.173) 6(-8,-2.173) 7(-7.75,5.173) 8(-7.5,-2.173) 9(-7.25,5.173) 10(-7,-2.173) 11(-6.75,5.173) 12(-6.5,-2.173) 13(-6.25,5.173) 14(-6,-2.173) 15(-5.75,5.173) 16(-5.5,-2.173) 17(-5.25,5.173) 18(-5,-2.173) 19(-4.75,5.173) 20(-4.5,-2.173) 21(-4.25,5.173) 22(-4,-2.173) 23(-3.75,5.173) 24(-3.5,-2.173) 25(-3.25,5.173) 26(-3,-2.173) 27(-2.75,5.173) 28(-2.5,-2.173) 29(-2.25,5.173) 30(-2,-2.173) 31(-1.75,5.173) 32(-1.5,-2.173) 33(-1.25,5.173) 34(-1,-2.173) 35(-0.75,5.173) 36(-0.5,-2.173) 37(-0.25,5.173) 38(0,-2.173) 39(0.25,5.173) 40(0.5,-2.173) 41(0.75,5.173) 42(1,-2.173) 43(1.25,5.173) 44(1.5,-2.173) 45(1.75,5.173) 46(2,-2.173) 47(2.25,5.173) 48(2.5,-2.173) 49(2.75,5.173) 50(3,-2.173) 51(3.25,5.173) 52(3.5,-2.173) 53(3.75,5.173) 54(4,-2.173) 55(4.25,5.173) 56(4.5,-2.173) 57(4.75,5.173) 58(5,-2.173) 67(7.25,5.173) 68(7.5,-2.173) 69(7.75,5.173) 70(8,-2.173) 71(8.25,5.173) 72(8.5,-2.173) 73(8.75,5.173) 74(9,-2.173) 75(9.25,5.173)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NTC-402H22-U
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
NTC-402H24-U
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
NTC-603H38
  rect 0.914x0.787 smd: 1(0,0.66) 2(0,-0.66)
OSC-3225-4P-4H30
  rect 1.397x1.067 smd: 1(-1.171,-0.756) 2(1.171,-0.756) 3(1.171,0.756) 4(-1.171,0.756)
OSC-3225-4P-4H36
  rect 1.397x1.067 smd: 1(-1.171,-0.756) 2(1.171,-0.756) 3(1.171,0.756) 4(-1.171,0.756)
POLYSW-2114H30
  rect 1.6x0.889 smd: 1(0,0.865) 2(0,-0.865)
POLYSW-4633-UH43
  rect 3.505x1.626 smd: 1(0,1.834) 2(0,-1.834)
PPAK-8P-3232H36
  rect 0.406x0.66 smd: 1(-0.975,-2.142) 2(-0.325,-2.142) 3(0.325,-2.142) 4(0.975,-2.142)
  rect 3.353x2.438 smd: 5(0,0)
  rect 0.025x0.025 smd: 6(0.65,0.838) 7(0,0.838) 8(-0.65,0.838)
PPAK-8P-G5324H44-COLAY
  rect 0.762x0.889 smd: 1(-1.905,-2.946) 2(-0.635,-2.946) 3(0.635,-2.946) 4(1.905,-2.946) 5(1.905,2.946) 6(0.635,2.946) 7(-0.635,2.946) 8(-1.905,2.946)
  rect 5.207x2.896 smd: 9(0,0.65)
  rect 5.207x0.787 smd: 10(0,-1.7)
QFN16-G1D8-UH32
  rect 0.305x0.66 smd: 1(0.75,1.487) 2(0.25,1.487) 3(-0.25,1.487) 4(-0.75,1.487) 9(-0.75,-1.487) 10(-0.25,-1.487) 11(0.25,-1.487) 12(0.75,-1.487)
  rect 0.66x0.305 smd: 5(-1.487,0.75) 6(-1.487,0.25) 7(-1.487,-0.25) 8(-1.487,-0.75) 13(1.487,-0.75) 14(1.487,-0.25) 15(1.487,0.25) 16(1.487,0.75)
  rect 1.778x1.778 smd: 17(0,0)
QFN20-G1D75H32
  rect 0.203x0.66 smd: 1(0.8,1.487) 2(0.4,1.487) 3(0,1.487) 4(-0.4,1.487) 5(-0.8,1.487) 11(-0.8,-1.487) 12(-0.4,-1.487) 13(0,-1.487) 14(0.4,-1.487) 15(0.8,-1.487)
  rect 0.66x0.203 smd: 6(-1.487,0.8) 7(-1.487,0.4) 8(-1.487,0) 9(-1.487,-0.4) 10(-1.487,-0.8) 16(1.487,-0.8) 17(1.487,-0.4) 18(1.487,0) 19(1.487,0.4) 20(1.487,0.8)
  rect 1.753x1.753 smd: 21(0,0)
QFN20J3-G1D8H32
  rect 0.203x0.635 smd: 1(0.8,1.437) 2(0.4,1.437) 3(0,1.437) 4(-0.4,1.437) 5(-0.8,1.437) 11(-0.8,-1.437) 12(-0.4,-1.437) 13(0,-1.437) 14(0.4,-1.437) 15(0.8,-1.437)
  rect 0.635x0.203 smd: 6(-1.437,0.8) 7(-1.437,0.4) 8(-1.437,0) 9(-1.437,-0.4) 10(-1.437,-0.8) 16(1.437,-0.8) 17(1.437,-0.4) 18(1.437,0) 19(1.437,0.4) 20(1.437,0.8)
  rect 1.803x1.803 smd: 21(0,0)
